File: hardware/ecp5_mainboard/miscio.sch (KiCad schematic (older format))
At the start: 26 parts

Commit message: hardware/mainboard: Connect DDR3 IO to FPGA IO
Signed-off-by: David Shah <dave@ds0.me>
Connections:
- net +1V8 renamed +1V35
Changed lines of the file:
@@
 $Descr A4 11693 8268
 encoding utf-8
-Sheet 7 8
+Sheet 7 9
 Title ""
 Date ""
@@
 	2050 5850 2050 5750
 Connection ~ 1950 5850
-$Comp
-L power:+1V8 #PWR?
-U 1 1 61399428
-P 3000 4200
-F 0 "#PWR?" H 3000 4050 50  0001 C CNN
-F 1 "+1V8" H 3015 4373 50  0000 C CNN
-F 2 "" H 3000 4200 50  0001 C CNN
-F 3 "" H 3000 4200 50  0001 C CNN
-	1    3000 4200
-	1    0    0    -1
-$EndComp
 Wire Wire Line
 	3000 4200 3000 4450
@@
 	1    0    0    -1
 $EndComp
-$Comp
-L power:+1V8 #PWR?
-U 1 1 613BDD1E
-P 5100 4150
-F 0 "#PWR?" H 5100 4000 50  0001 C CNN
-F 1 "+1V8" H 5115 4323 50  0000 C CNN
-F 2 "" H 5100 4150 50  0001 C CNN
-F 3 "" H 5100 4150 50  0001 C CNN
-	1    5100 4150
-	1    0    0    -1
-$EndComp
-Wire Wire Line
-	5100 4150 5100 4450
+Wire Wire Line
+	5100 4200 5100 4450
 Wire Wire Line
 	5100 5150 4950 5150
@@
 	4100 4450 4000 4450
 Connection ~ 4100 4450
+$Comp
+L power:+1V35 #PWR?
+U 1 1 61FB5AD2
+P 3000 4200
+F 0 "#PWR?" H 3000 4050 50  0001 C CNN
+F 1 "+1V35" H 3015 4373 50  0000 C CNN
+F 2 "" H 3000 4200 50  0001 C CNN
+F 3 "" H 3000 4200 50  0001 C CNN
+	1    3000 4200
+	1    0    0    -1
+$EndComp
+$Comp
+L power:+1V35 #PWR?
+U 1 1 61FB5BB5
+P 5100 4200
+F 0 "#PWR?" H 5100 4050 50  0001 C CNN
+F 1 "+1V35" H 5115 4373 50  0000 C CNN
+F 2 "" H 5100 4200 50  0001 C CNN
+F 3 "" H 5100 4200 50  0001 C CNN
+	1    5100 4200
+	1    0    0    -1
+$EndComp
 $EndSCHEMATC

Commit message: hardware/mainboard: Re-annotate and fix ERC
Signed-off-by: David Shah <dave@ds0.me>
Parts:
- gave numbers to parts that had none: 26
Changed lines of the file:
@@
 $EndDescr
 $Comp
-L Device:LED_Dual_ACAC D?
+L Device:LED_Dual_ACAC D14
 U 1 1 61049D89
 P 2400 950
-F 0 "D?" H 2400 1375 50  0000 C CNN
+F 0 "D14" H 2400 1375 50  0000 C CNN
 F 1 "APHB1608QBDSYKC" H 2400 1284 50  0000 C CNN
 F 2 "" H 2430 950 50  0001 C CNN
@@
 	2100 1050 2050 1050
 $Comp
-L power:+3V3 #PWR?
+L power:+3V3 #PWR0166
 U 1 1 6104A023
 P 900 850
-F 0 "#PWR?" H 900 700 50  0001 C CNN
+F 0 "#PWR0166" H 900 700 50  0001 C CNN
 F 1 "+3V3" V 915 978 50  0000 L CNN
 F 2 "" H 900 850 50  0001 C CNN
@@
 	2050 1000 2050 950
 $Comp
-L Device:LED_Dual_ACAC D?
+L Device:LED_Dual_ACAC D15
 U 1 1 6104A4AF
 P 2400 1650
-F 0 "D?" H 2400 2075 50  0000 C CNN
+F 0 "D15" H 2400 2075 50  0000 C CNN
 F 1 "APHB1608QBDSYKC" H 2400 1984 50  0000 C CNN
 F 2 "" H 2430 1650 50  0001 C CNN
@@
 	2050 1700 2050 1650
 $Comp
-L Device:LED_Dual_ACAC D?
+L Device:LED_Dual_ACAC D16
 U 1 1 6104A7EB
 P 2400 2350
-F 0 "D?" H 2400 2775 50  0000 C CNN
+F 0 "D16" H 2400 2775 50  0000 C CNN
 F 1 "APHB1608QBDSYKC" H 2400 2684 50  0000 C CNN
 F 2 "" H 2430 2350 50  0001 C CNN
@@
 	2050 2400 2050 2350
 $Comp
-L Device:LED_Dual_ACAC D?
+L Device:LED_Dual_ACAC D17
 U 1 1 6104AE36
 P 2400 3100
-F 0 "D?" H 2400 3525 50  0000 C CNN
+F 0 "D17" H 2400 3525 50  0000 C CNN
 F 1 "APHB1608QBDSYKC" H 2400 3434 50  0000 C CNN
 F 2 "" H 2430 3100 50  0001 C CNN
@@
 	2050 3150 2050 3100
 $Comp
-L Device:LED_Dual_ACAC D?
+L Device:LED_Dual_ACAC D18
 U 1 1 6104D817
 P 5100 950
-F 0 "D?" H 5100 1375 50  0000 C CNN
+F 0 "D18" H 5100 1375 50  0000 C CNN
 F 1 "APHB1608QBDCGKC" H 5100 1284 50  0000 C CNN
 F 2 "" H 5130 950 50  0001 C CNN
@@
 	4750 1000 4750 950
 $Comp
-L Device:LED_Dual_ACAC D?
+L Device:LED_Dual_ACAC D19
 U 1 1 610547CD
 P 5100 1650
-F 0 "D?" H 5100 2075 50  0000 C CNN
+F 0 "D19" H 5100 2075 50  0000 C CNN
 F 1 "APHB1608QBDCGKC" H 5100 1984 50  0000 C CNN
 F 2 "" H 5130 1650 50  0001 C CNN
@@
 	4750 1700 4750 1650
 $Comp
-L Device:LED_Dual_ACAC D?
+L Device:LED_Dual_ACAC D20
 U 1 1 61055BAD
 P 5100 2350
-F 0 "D?" H 5100 2775 50  0000 C CNN
+F 0 "D20" H 5100 2775 50  0000 C CNN
 F 1 "APHB1608QBDCGKC" H 5100 2684 50  0000 C CNN
 F 2 "" H 5130 2350 50  0001 C CNN
@@
 	4750 2400 4750 2350
 $Comp
-L Device:LED_Dual_ACAC D?
+L Device:LED_Dual_ACAC D21
 U 1 1 610575DB
 P 5100 3100
-F 0 "D?" H 5100 3525 50  0000 C CNN
+F 0 "D21" H 5100 3525 50  0000 C CNN
 F 1 "APHB1608QBDCGKC" H 5100 3434 50  0000 C CNN
 F 2 "" H 5130 3100 50  0001 C CNN
@@
 	4750 3150 4750 3100
 $Comp
-L Device:LED_Dual_ACAC D?
+L Device:LED_Dual_ACAC D22
 U 1 1 61061FE6
 P 7850 950
-F 0 "D?" H 7850 1375 50  0000 C CNN
+F 0 "D22" H 7850 1375 50  0000 C CNN
 F 1 "APHB1608CGKSURKC" H 7850 1284 50  0000 C CNN
 F 2 "" H 7880 950 50  0001 C CNN
@@
 	7500 1000 7500 950
 $Comp
-L Device:LED_Dual_ACAC D?
+L Device:LED_Dual_ACAC D23
 U 1 1 6106ADE3
 P 7850 1650
-F 0 "D?" H 7850 2075 50  0000 C CNN
+F 0 "D23" H 7850 2075 50  0000 C CNN
 F 1 "APHB1608CGKSURKC" H 7850 1984 50  0000 C CNN
 F 2 "" H 7880 1650 50  0001 C CNN
@@
 	7500 1700 7500 1650
 $Comp
-L Device:LED_Dual_ACAC D?
+L Device:LED_Dual_ACAC D24
 U 1 1 6106FCCD
 P 7850 2350
-F 0 "D?" H 7850 2775 50  0000 C CNN
+F 0 "D24" H 7850 2775 50  0000 C CNN
 F 1 "APHB1608CGKSURKC" H 7850 2684 50  0000 C CNN
 F 2 "" H 7880 2350 50  0001 C CNN
@@
 	7500 2400 7500 2350
 $Comp
-L Device:LED_Dual_ACAC D?
+L Device:LED_Dual_ACAC D25
 U 1 1 61073A02
 P 7850 3100
-F 0 "D?" H 7850 3525 50  0000 C CNN
+F 0 "D25" H 7850 3525 50  0000 C CNN
 F 1 "APHB1608CGKSURKC" H 7850 3434 50  0000 C CNN
 F 2 "" H 7880 3100 50  0001 C CNN
@@
 	7500 3150 7500 3100
 $Comp
-L Device:R_Pack04 RN?
+L Device:R_Pack04 RN7
 U 1 1 6108969C
 P 1250 1050
-F 0 "RN?" V 833 1050 50  0000 C CNN
+F 0 "RN7" V 833 1050 50  0000 C CNN
 F 1 "1k" V 924 1050 50  0000 C CNN
 F 2 "" V 1525 1050 50  0001 C CNN
@@
 	950  950  950  1050
 $Comp
-L power:+3V3 #PWR?
+L power:+3V3 #PWR0170
 U 1 1 610C4922
 P 3600 850
-F 0 "#PWR?" H 3600 700 50  0001 C CNN
+F 0 "#PWR0170" H 3600 700 50  0001 C CNN
 F 1 "+3V3" V 3615 978 50  0000 L CNN
 F 2 "" H 3600 850 50  0001 C CNN
@@
 	3600 850  3650 850
 $Comp
-L Device:R_Pack04 RN?
+L Device:R_Pack04 RN11
 U 1 1 610C4929
 P 3950 1050
-F 0 "RN?" V 3533 1050 50  0000 C CNN
+F 0 "RN11" V 3533 1050 50  0000 C CNN
 F 1 "1k" V 3624 1050 50  0000 C CNN
 F 2 "" V 4225 1050 50  0001 C CNN
@@
 	4350 1550 4800 1550
 $Comp
-L power:+3V3 #PWR?
+L power:+3V3 #PWR0174
 U 1 1 610D14C1
 P 6350 850
-F 0 "#PWR?" H 6350 700 50  0001 C CNN
+F 0 "#PWR0174" H 6350 700 50  0001 C CNN
 F 1 "+3V3" V 6365 978 50  0000 L CNN
 F 2 "" H 6350 850 50  0001 C CNN
@@
 	6350 850  6400 850
 $Comp
-L Device:R_Pack04 RN?
+L Device:R_Pack04 RN14
 U 1 1 610D14C8
 P 6700 1050
-F 0 "RN?" V 6283 1050 50  0000 C CNN
+F 0 "RN14" V 6283 1050 50  0000 C CNN
 F 1 "2.2k" V 6374 1050 50  0000 C CNN
 F 2 "" V 6975 1050 50  0001 C CNN
@@
 	7100 1550 7550 1550
 $Comp
-L Device:R_Pack04 RN?
+L Device:R_Pack04 RN10
 U 1 1 610ED07B
 P 3200 3100
-F 0 "RN?" V 2783 3100 50  0000 C CNN
+F 0 "RN10" V 2783 3100 50  0000 C CNN
 F 1 "2.2k" V 2874 3100 50  0000 C CNN
 F 2 "" V 3475 3100 50  0001 C CNN
@@
 	3500 3200 3500 3350
 $Comp
-L power:GND #PWR?
+L power:GND #PWR0169
 U 1 1 6112AD66
 P 3500 3350
-F 0 "#PWR?" H 3500 3100 50  0001 C CNN
+F 0 "#PWR0169" H 3500 3100 50  0001 C CNN
 F 1 "GND" H 3505 3177 50  0000 C CNN
 F 2 "" H 3500 3350 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:R_Pack04 RN?
+L Device:R_Pack04 RN13
 U 1 1 6112AFE5
 P 5900 3100
-F 0 "RN?" V 5483 3100 50  0000 C CNN
+F 0 "RN13" V 5483 3100 50  0000 C CNN
 F 1 "2.2k" V 5574 3100 50  0000 C CNN
 F 2 "" V 6175 3100 50  0001 C CNN
@@
 	6200 3200 6200 3350
 $Comp
-L power:GND #PWR?
+L power:GND #PWR0173
 U 1 1 6112B000
 P 6200 3350
-F 0 "#PWR?" H 6200 3100 50  0001 C CNN
+F 0 "#PWR0173" H 6200 3100 50  0001 C CNN
 F 1 "GND" H 6205 3177 50  0000 C CNN
 F 2 "" H 6200 3350 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:R_Pack04 RN?
+L Device:R_Pack04 RN15
 U 1 1 61158C15
 P 8650 3100
-F 0 "RN?" V 8233 3100 50  0000 C CNN
+F 0 "RN15" V 8233 3100 50  0000 C CNN
 F 1 "2.2k" V 8324 3100 50  0000 C CNN
 F 2 "" V 8925 3100 50  0001 C CNN
@@
 	8950 3200 8950 3350
 $Comp
-L power:GND #PWR?
+L power:GND #PWR0175
 U 1 1 61158C30
 P 8950 3350
-F 0 "#PWR?" H 8950 3100 50  0001 C CNN
+F 0 "#PWR0175" H 8950 3100 50  0001 C CNN
 F 1 "GND" H 8955 3177 50  0000 C CNN
 F 2 "" H 8950 3350 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Switch:SW_DIP_x08 SW?
+L Switch:SW_DIP_x08 SW1
 U 1 1 61180D92
 P 2550 4850
-F 0 "SW?" H 2550 5517 50  0000 C CNN
+F 0 "SW1" H 2550 5517 50  0000 C CNN
 F 1 " CHP-081TA" H 2550 5426 50  0000 C CNN
 F 2 "" H 2550 4850 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:R_Pack04 RN?
+L Device:R_Pack04 RN8
 U 1 1 61180EE4
 P 1550 5550
-F 0 "RN?" V 900 5550 50  0000 C CNN
+F 0 "RN8" V 900 5550 50  0000 C CNN
 F 1 "10k" V 1100 5550 50  0000 C CNN
 F 2 "" V 1825 5550 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:R_Pack04 RN?
+L Device:R_Pack04 RN9
 U 1 1 61180FF0
 P 1950 5550
-F 0 "RN?" V 1000 5550 50  0000 C CNN
+F 0 "RN9" V 1000 5550 50  0000 C CNN
 F 1 "10k" V 1200 5550 50  0000 C CNN
 F 2 "" V 2225 5550 50  0001 C CNN
@@
 	3000 5050 3000 4950
 $Comp
-L power:GND #PWR?
+L power:GND #PWR0167
 U 1 1 61301DBE
 P 1700 5950
-F 0 "#PWR?" H 1700 5700 50  0001 C CNN
+F 0 "#PWR0167" H 1700 5700 50  0001 C CNN
 F 1 "GND" H 1705 5777 50  0000 C CNN
 F 2 "" H 1700 5950 50  0001 C CNN
@@
 	3000 4200 3000 4450
 $Comp
-L Switch:SW_Push SW?
+L Switch:SW_Push SW2
 U 1 1 613BDBB0
 P 4750 4450
-F 0 "SW?" H 4750 4735 50  0000 C CNN
+F 0 "SW2" H 4750 4735 50  0000 C CNN
 F 1 "SW_Push" H 4750 4644 50  0000 C CNN
 F 2 "" H 4750 4650 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Switch:SW_Push SW?
+L Switch:SW_Push SW3
 U 1 1 613BDC44
 P 4750 4800
-F 0 "SW?" H 4750 5085 50  0000 C CNN
+F 0 "SW3" H 4750 5085 50  0000 C CNN
 F 1 "SW_Push" H 4750 4994 50  0000 C CNN
 F 2 "" H 4750 5000 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Switch:SW_Push SW?
+L Switch:SW_Push SW4
 U 1 1 613BDC8C
 P 4750 5150
-F 0 "SW?" H 4750 5435 50  0000 C CNN
+F 0 "SW4" H 4750 5435 50  0000 C CNN
 F 1 "SW_Push" H 4750 5344 50  0000 C CNN
 F 2 "" H 4750 5350 50  0001 C CNN
@@
 	5100 4450 5100 4800
 $Comp
-L Switch:SW_Push SW?
+L Switch:SW_Push SW5
 U 1 1 6141A92D
 P 4750 5550
-F 0 "SW?" H 4750 5835 50  0000 C CNN
+F 0 "SW5" H 4750 5835 50  0000 C CNN
 F 1 "SW_Push" H 4750 5744 50  0000 C CNN
 F 2 "" H 4750 5750 50  0001 C CNN
@@
 Connection ~ 5100 5150
 $Comp
-L Device:R_Pack04 RN?
+L Device:R_Pack04 RN12
 U 1 1 6142D984
 P 4300 5900
-F 0 "RN?" V 3900 5900 50  0000 C CNN
+F 0 "RN12" V 3900 5900 50  0000 C CNN
 F 1 "10k" V 4000 5900 50  0000 C CNN
 F 2 "" V 4575 5900 50  0001 C CNN
@@
 	4200 6200 4250 6200
 $Comp
-L power:GND #PWR?
+L power:GND #PWR0171
 U 1 1 614E18C8
 P 4250 6300
-F 0 "#PWR?" H 4250 6050 50  0001 C CNN
+F 0 "#PWR0171" H 4250 6050 50  0001 C CNN
 F 1 "GND" H 4255 6127 50  0000 C CNN
 F 2 "" H 4250 6300 50  0001 C CNN
@@
 Connection ~ 4100 4450
 $Comp
-L power:+1V35 #PWR?
+L power:+1V35 #PWR0168
 U 1 1 61FB5AD2
 P 3000 4200
-F 0 "#PWR?" H 3000 4050 50  0001 C CNN
+F 0 "#PWR0168" H 3000 4050 50  0001 C CNN
 F 1 "+1V35" H 3015 4373 50  0000 C CNN
 F 2 "" H 3000 4200 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:+1V35 #PWR?
+L power:+1V35 #PWR0172
 U 1 1 61FB5BB5
 P 5100 4200
-F 0 "#PWR?" H 5100 4050 50  0001 C CNN
+F 0 "#PWR0172" H 5100 4050 50  0001 C CNN
 F 1 "+1V35" H 5115 4373 50  0000 C CNN
 F 2 "" H 5100 4200 50  0001 C CNN

Commit message: hardware/mainboard: Assign some footprints
Signed-off-by: David Shah <dave@ds0.me>
Parts:
- RN10, RN11, RN12, RN13, RN14, RN15, RN7, RN8, RN9: footprint (none) -> Resistor_SMD:R_Array_Convex_4x0402
Changed lines of the file:
@@
 F 0 "RN7" V 833 1050 50  0000 C CNN
 F 1 "1k" V 924 1050 50  0000 C CNN
-F 2 "" V 1525 1050 50  0001 C CNN
+F 2 "Resistor_SMD:R_Array_Convex_4x0402" V 1525 1050 50  0001 C CNN
 F 3 "~" H 1250 1050 50  0001 C CNN
 	1    1250 1050
@@
 F 0 "RN11" V 3533 1050 50  0000 C CNN
 F 1 "1k" V 3624 1050 50  0000 C CNN
-F 2 "" V 4225 1050 50  0001 C CNN
+F 2 "Resistor_SMD:R_Array_Convex_4x0402" V 4225 1050 50  0001 C CNN
 F 3 "~" H 3950 1050 50  0001 C CNN
 	1    3950 1050
@@
 F 0 "RN14" V 6283 1050 50  0000 C CNN
 F 1 "2.2k" V 6374 1050 50  0000 C CNN
-F 2 "" V 6975 1050 50  0001 C CNN
+F 2 "Resistor_SMD:R_Array_Convex_4x0402" V 6975 1050 50  0001 C CNN
 F 3 "~" H 6700 1050 50  0001 C CNN
 	1    6700 1050
@@
 F 0 "RN10" V 2783 3100 50  0000 C CNN
 F 1 "2.2k" V 2874 3100 50  0000 C CNN
-F 2 "" V 3475 3100 50  0001 C CNN
+F 2 "Resistor_SMD:R_Array_Convex_4x0402" V 3475 3100 50  0001 C CNN
 F 3 "~" H 3200 3100 50  0001 C CNN
 	1    3200 3100
@@
 F 0 "RN13" V 5483 3100 50  0000 C CNN
 F 1 "2.2k" V 5574 3100 50  0000 C CNN
-F 2 "" V 6175 3100 50  0001 C CNN
+F 2 "Resistor_SMD:R_Array_Convex_4x0402" V 6175 3100 50  0001 C CNN
 F 3 "~" H 5900 3100 50  0001 C CNN
 	1    5900 3100
@@
 F 0 "RN15" V 8233 3100 50  0000 C CNN
 F 1 "2.2k" V 8324 3100 50  0000 C CNN
-F 2 "" V 8925 3100 50  0001 C CNN
+F 2 "Resistor_SMD:R_Array_Convex_4x0402" V 8925 3100 50  0001 C CNN
 F 3 "~" H 8650 3100 50  0001 C CNN
 	1    8650 3100
@@
 F 0 "RN8" V 900 5550 50  0000 C CNN
 F 1 "10k" V 1100 5550 50  0000 C CNN
-F 2 "" V 1825 5550 50  0001 C CNN
+F 2 "Resistor_SMD:R_Array_Convex_4x0402" V 1825 5550 50  0001 C CNN
 F 3 "~" H 1550 5550 50  0001 C CNN
 	1    1550 5550
@@
 F 0 "RN9" V 1000 5550 50  0000 C CNN
 F 1 "10k" V 1200 5550 50  0000 C CNN
-F 2 "" V 2225 5550 50  0001 C CNN
+F 2 "Resistor_SMD:R_Array_Convex_4x0402" V 2225 5550 50  0001 C CNN
 F 3 "~" H 1950 5550 50  0001 C CNN
 	1    1950 5550
@@
 F 0 "RN12" V 3900 5900 50  0000 C CNN
 F 1 "10k" V 4000 5900 50  0000 C CNN
-F 2 "" V 4575 5900 50  0001 C CNN
+F 2 "Resistor_SMD:R_Array_Convex_4x0402" V 4575 5900 50  0001 C CNN
 F 3 "~" H 4300 5900 50  0001 C CNN
 	1    4300 5900
