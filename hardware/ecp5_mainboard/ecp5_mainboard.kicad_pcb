# Repository gatecat/TrellisBoard (continued)

## KiCad design hardware/ecp5_mainboard/ecp5_mainboard.kicad_pcb (continued)

Parts:
C99, C100, C101, C102, C103, C104, C105, C106, C118: 100n; C_0402_1005Metric
C107, C109: 10µ; C_0805_2012Metric
C108, C110, C111, C112, C113, C114, C116: 470n; C_0402_1005Metric
C115, C117: DNP; C_0402_1005Metric
D13: GREEN; LED_0805_2012Metric
DA1, DA2, DA3, DA4: TPD4E02B04; USON10
FB1, FB2, FB3: 200R@100MHz; L_0603_1608Metric
JP1: PRSNT; PinHeader_1x03_P2.54mm_Vertical
P1, P2: SATA; Molex_SATA_047080-4001
P3: PCIe_x4_EDGE; PCIe_EDGE_x4
R47: 1k; R_0402_1005Metric
R48: 4.7k; R_0402_1005Metric
R49: DNP; R_0402_1005Metric
R50, R51: 2.2k; R_0402_1005Metric
R52: 2.2; R_0402_1005Metric
R53, R55: 0R; R_0805_2012Metric
R54, R56: DNP; R_0805_2012Metric
R57: 10k; R_0402_1005Metric
R58: 0R; R_0402_1005Metric
TP1: DCU1_CLK+; TestPoint_Pad_1.5x1.5mm
TP2: DCU1_CLK-; TestPoint_Pad_1.5x1.5mm
U14: XUL535150.000JS6I8; OSC_IDT_XU_5x3.2mm
U15: ECP5UM5G_85_CABGA756; CABGA756_27x27mm_p0.8mm
U16: 5P49V6965; QFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm
Y1: 25MHz; Crystal_Epsom_TSX-3225

Connections:
+1V8: FB1.2, R50.1, R51.1; also elsewhere on the board
+3V3: FB2.2, FB3.2; also elsewhere on the board
/PCIe + SATA/1V8_C: C107.1, C108.1, FB1.1, U16.15 (VddO3), U16.21 (VddO1)
/PCIe + SATA/3V3_C: C109.1, C110.1, C112.1, C113.1, C114.1, FB2.1, R52.2, U16.10 (VddO4), U16.18 (VddO2), U16.22 (VddD), U16.23 (VddO0)
/PCIe + SATA/3V3_CA: C116.1, C118.1, R52.1, U16.5 (VddA)
/PCIe + SATA/CLK150M+: R53.2, U14.4 (OUT+)
/PCIe + SATA/CLK150M-: R55.2, U14.5 (OUT-)
/PCIe + SATA/CLKAUXO+: R54.2, U16.14 (OUT3+)
/PCIe + SATA/CLKAUXO-: R56.2, U16.13 (OUT3-)
/PCIe + SATA/DCU0_REFCLK+: U15.AM14 (REFCLKP_D0), U16.20 (OUT1+)
/PCIe + SATA/DCU0_REFCLK-: U15.AM15 (REFCLKN_D0), U16.19 (OUT1-)
/PCIe + SATA/DCU0_RX0+: DA4.1 (IO1), DA4.10, P3.B14 (HSO0+), U15.AM8 (HDRXP0_D0CH0)
/PCIe + SATA/DCU0_RX0-: DA4.2 (IO2), DA4.9, P3.B15 (HSO0-), U15.AM9 (HDRXN0_D0CH0)
/PCIe + SATA/DCU0_RX1+: DA4.4 (IO3), DA4.7, P3.B19 (HSO1+), U15.AK12 (HDTXP0_D0CH1)
/PCIe + SATA/DCU0_RX1-: DA4.5 (IO4), DA4.6, P3.B20 (HSO1-), U15.AK13 (HDTXN0_D0CH1)
/PCIe + SATA/DCU0_TX0+: C103.2, U15.AK9 (HDTXP0_D0CH0)
/PCIe + SATA/DCU0_TX0-: C104.2, U15.AK10 (HDTXN0_D0CH0)
/PCIe + SATA/DCU0_TX1+: C105.2, U15.AM11 (HDRXP0_D0CH1)
/PCIe + SATA/DCU0_TX1-: C106.2, U15.AM12 (HDRXN0_D0CH1)
/PCIe + SATA/DCU1_REFCLK+: R53.1, R54.1, TP1.1, U15.AM23 (REFCLKP_D1)
/PCIe + SATA/DCU1_REFCLK-: R55.1, R56.1, TP2.1, U15.AM24 (REFCLKN_D1)
/PCIe + SATA/DCU1_RX0+: DA1.5 (IO4), DA1.6, P1.6 (B+/RX+), U15.AM17 (HDRXP0_D1CH0)
/PCIe + SATA/DCU1_RX0-: DA1.4 (IO3), DA1.7, P1.5 (B-/RX-), U15.AM18 (HDRXN0_D1CH0)
/PCIe + SATA/DCU1_RX1+: DA2.5 (IO4), DA2.6, P2.6 (B+/RX+), U15.AK21 (HDTXP0_D1CH1)
/PCIe + SATA/DCU1_RX1-: DA2.4 (IO3), DA2.7, P2.5 (B-/RX-), U15.AK22 (HDTXN0_D1CH1)
/PCIe + SATA/DCU1_TX0+: C99.2, U15.AK18 (HDTXP0_D1CH0)
/PCIe + SATA/DCU1_TX0-: C100.2, U15.AK19 (HDTXN0_D1CH0)
/PCIe + SATA/DCU1_TX1+: C101.2, U15.AM20 (HDRXP0_D1CH1)
/PCIe + SATA/DCU1_TX1-: C102.2, U15.AM21 (HDRXN0_D1CH1)
/PCIe + SATA/PCIe_HSI0+: C103.1, DA3.1 (IO1), DA3.10, P3.A16 (HSI0+)
/PCIe + SATA/PCIe_HSI0-: C104.1, DA3.2 (IO2), DA3.9, P3.A17 (HSI0-)
/PCIe + SATA/PCIe_HSI1+: C105.1, DA3.4 (IO3), DA3.7, P3.A21 (HSI1+)
/PCIe + SATA/PCIe_HSI1-: C106.1, DA3.5 (IO4), DA3.6, P3.A22 (HSI1-)
/PCIe + SATA/PCIe_REFCLK+: P3.A13 (REFCLK+), R49.1, U16.1 (CLKIN+)
/PCIe + SATA/PCIe_REFCLK-: P3.A14 (REFCLK-), R49.2, U16.2 (CLKIN-)
/PCIe + SATA/SATA0_A+: C99.1, DA1.1 (IO1), DA1.10, P1.2 (A+/TX+)
/PCIe + SATA/SATA0_A-: C100.1, DA1.2 (IO2), DA1.9, P1.3 (A-/TX-)
/PCIe + SATA/SATA1_A+: C101.1, DA2.1 (IO1), DA2.10, P2.2 (A+/TX+)
/PCIe + SATA/SATA1_A-: C102.1, DA2.2 (IO2), DA2.9, P2.3 (A-/TX-)
/PCIe + SATA/~PRSNT1: JP1.2 (C), P3.A1 (~PRSNT1)
/PCIe + SATA/~PRSNT2~_X1: JP1.1 (A), P3.B17 (~PRSNT2)
/PCIe + SATA/~PRSNT2~_X4: JP1.3 (B), P3.B31 (~PRSNT2)
CLK_SCL: R51.2, U16.9 (SEL0/SCL); also elsewhere on the board
CLK_SDA: R50.2, U16.8 (SEL1/SDA); also elsewhere on the board
CLK_SD_OE: U16.7 (SD/OE); also elsewhere on the board
FABRIC_REFCLK: R58.1; also elsewhere on the board
GND: C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.1, C116.2, C117.2, C118.2, D13.1 (K), DA1.3 (GND), DA1.8, DA2.3 (GND), DA2.8, DA3.3 (GND), DA3.8, DA4.3 (GND), DA4.8, P1.1 (GND), P1.4 (GND), P1.7 (GND), P1.S, P2.1 (GND), P2.4 (GND), P2.7 (GND), P2.S, P3.A4 (GND), P3.A12 (GND), P3.A15 (GND), P3.A18 (GND), P3.A20 (GND), P3.A23 (GND), P3.A24 (GND), P3.A27 (GND), P3.A28 (GND), P3.A31 (GND), P3.B4 (GND), P3.B7 (GND), P3.B13 (GND), P3.B16 (GND), P3.B18 (GND), P3.B21 (GND), P3.B22 (GND), P3.B25 (GND), P3.B26 (GND), P3.B29 (GND), P3.B32 (GND), R57.2, U14.3 (GND), U16.25 (GND), Y1.3; also elsewhere on the board
unnamed: C111.1, FB3.1, U14.6 (Vdd)
unnamed: C115.2, U16.4 (XIN/REF), Y1.1
unnamed: C117.1, U16.3 (XOUT), Y1.2
unnamed: D13.2 (A), R48.1
unnamed: P3.A11 (~PERST), R47.2
unnamed: R57.1, U16.6 (CLKSEL)
unnamed: R58.2, U16.17 (OUT2+)
PCIe_12V: P3.A2 (+12V), P3.A3 (+12V), P3.B1 (+12V), P3.B2 (+12V), P3.B3 (+12V), R48.2; also elsewhere on the board
PCIe_~WAKE: P3.B11 (~WAKE); also elsewhere on the board
~PERST: R47.1; also elsewhere on the board

Parts:
C119, C120, C123, C124, C125, C255: 10µ; C_0805_2012Metric
C121: 100p; C_0402_1005Metric
C122, C140, C156, C159, C162, C163: 470n; C_0402_1005Metric
C126, C127, C128, C129, C130, C131: 10n; C_0402_1005Metric
C132, C133, C134, C135, C141, C166, C167, C168, C169, C170, C171: 100n; C_0402_1005Metric
C136, C143: 22p; C_0402_1005Metric
C137: 100u; CP_Elec_6.3x5.8
C138, C139, C142, C161, C164, C165, C172, C173: 4.7µ; C_0603_1608Metric
C144, C145, C146, C148, C149, C150, C152, C153, C154, C155, C157, C158, C160: 10n; C_0201_0603Metric
C147, C151: 12p; C_0402_1005Metric
DA5, DA6: TPD4E02B04; USON10
FB4, FB5, FB6, FB7, FB8, FB9: 100R; L_0603_1608Metric
J3: HDMI_A; Molex_HDMI_A_47151-0001
J4: USB_A; 292303-7
J13: Micro_SD_Card; microSD_HC_Hirose_DM3AT-SF-PEJM5
P4: JK0654219NL; Pulse_MagJack_JK0654219NL
R59, R60, R67, R68: 2.2k; R_0402_1005Metric
R61: 200k; R_0402_1005Metric
R62: 510; R_0402_1005Metric
R63, R64, R65, R66, R73: 1k; R_0402_1005Metric
R69, R70, R96: 10k; R_0402_1005Metric
R71: 12.1k; R_0402_1005Metric
R72: 1M; R_0402_1005Metric
R74: 120k; R_0402_1005Metric
RN4, RN5, RN6, RN24: 10k; R_Array_Convex_4x0402
U17, U20: TPS2041B; SOT-23-5
U18: PCA9306; VSSOP-8_2.3x2mm_P0.5mm
U19: TFP410; HTQFP-64-1EP_10x10mm_P0.5mm_EP8x8mm_Mask4.4x4.4mm_ThermalVi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
U21: KSZ9031RNXCA; QFN-48-1EP_7x7mm_P0.5mm_EP5.15x5.15mm
U22: USB3300-EZK; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm
Y2: 25MHz; Crystal_Epsom_TSX-3225
Y3: 24MHz; Crystal_Epsom_TSX-3225

Connections:
+1V2: C148.1, C149.1, C150.1, C152.1, C153.1, C156.1, C159.1, C162.1, C164.1, FB7.1, FB8.1, U21.14 (DVDDL), U21.18 (DVDDL), U21.23 (DVDDL), U21.26 (DVDDL), U21.30 (DVDDL), U21.39 (DVDDL); also elsewhere on the board
+3V3: C122.1, C155.1, C158.1, C160.1, C163.1, C165.1, C166.1, C167.1, C168.1, C170.1, C172.1, C255.1, FB4.2, FB5.2, FB6.2, FB9.1, J13.4 (VDD), R62.2, R66.2, R67.1, R68.1, R69.1, R96.1, RN4.5 (R4.2), RN4.6 (R3.2), RN4.7 (R2.2), RN4.8 (R1.2), RN5.5 (R4.2), RN5.6 (R3.2), RN5.8 (R1.2), RN6.7 (R2.2), RN6.8 (R1.2), RN24.5 (R4.2), RN24.6 (R3.2), RN24.7 (R2.2), RN24.8 (R1.2), U18.2 (VREF1), U19.3 (VREF), U21.16 (DVDDH), U21.34 (DVDDH), U21.40 (DVDDH), U22.6 (VDD3.3), U22.16 (VDD3.3), U22.25 (VDD3.3), U22.30 (VDD3.3), U22.31 (REG_EN); also elsewhere on the board
+5V: C119.2, C142.1, R59.2, R60.2, R61.2, U17.5 (IN), U20.5 (IN); also elsewhere on the board
/HDMI, GbE, USB/AVDDH: C154.1, C157.1, C161.1, FB9.2, U21.1 (AVDDH), U21.12 (AVDDH)
/HDMI, GbE, USB/AVDDL: C138.1, C140.2, C144.1, C146.1, FB7.2, U21.4 (AVDDL), U21.9 (AVDDL)
/HDMI, GbE, USB/AVDDL_PLL: C139.1, C141.2, C145.2, FB8.2, U21.44 (AVDDL_PLL)
/HDMI, GbE, USB/DVI_DVDD: C123.1, C126.1, C129.1, C131.1, FB4.1, U19.1 (DVDD), U19.12 (DVDD), U19.33 (DVDD)
/HDMI, GbE, USB/DVI_PVDD: C124.1, C127.1, FB5.1, U19.18 (PVDD)
/HDMI, GbE, USB/DVI_TVDD: C125.1, C128.1, C130.1, FB6.1, U19.23 (TVDD), U19.29 (TVDD)
/HDMI, GbE, USB/ETH_LED1: R63.1, RN6.3 (R3.1), U21.17 (LED1/PHAD0/PME_N1)
/HDMI, GbE, USB/ETH_LED2: R64.1, RN6.4 (R4.1), U21.15 (LED2/PHYAD1)
/HDMI, GbE, USB/ETH_XI: C136.2, U21.46 (XI), Y2.1
/HDMI, GbE, USB/ETH_XO: C143.1, U21.45 (XO), Y2.2
/HDMI, GbE, USB/EXTVBUS: R69.2, U20.3 (~OC), U22.10 (EXTVBUS)
/HDMI, GbE, USB/HDMI_5V: C120.2, J3.18 (+5V), U17.1 (OUT)
/HDMI, GbE, USB/HDMI_HPD: J3.19 (HPD), R65.2
/HDMI, GbE, USB/MX1+: P4.11 (MX1+), U21.11 (TXRXM_D)
/HDMI, GbE, USB/MX1-: P4.10 (MX1-), U21.10 (TXRXP_D)
/HDMI, GbE, USB/MX2+: P4.4 (MX2+), U21.8 (TXRXM_C)
/HDMI, GbE, USB/MX2-: P4.5 (MX2-), U21.7 (TXRXP_C)
/HDMI, GbE, USB/MX3+: P4.3 (MX3+), U21.6 (TXRXM_B)
/HDMI, GbE, USB/MX3-: P4.2 (MX3-), U21.5 (TXRXP_B)
/HDMI, GbE, USB/MX4+: P4.8 (MX4+), U21.3 (TXRXM_A)
/HDMI, GbE, USB/MX4-: P4.9 (MX4-), U21.2 (TXRXP_A)
/HDMI, GbE, USB/PORT_SCL: J3.15 (SCL), R59.1, U18.6 (SCL2)
/HDMI, GbE, USB/PORT_SDA: J3.16 (SDA), R60.1, U18.5 (SDA2)
/HDMI, GbE, USB/TMDS_CLK+: DA6.4 (IO3), DA6.7, J3.10 (CK+), U19.22 (TXC+)
/HDMI, GbE, USB/TMDS_CLK-: DA6.5 (IO4), DA6.6, J3.12 (CK-), U19.21 (TXC-)
/HDMI, GbE, USB/TMDS_D0+: DA6.1 (IO1), DA6.10, J3.7 (D0+), U19.25 (TX0+)
/HDMI, GbE, USB/TMDS_D0-: DA6.2 (IO2), DA6.9, J3.9 (D0-), U19.24 (TX0-)
/HDMI, GbE, USB/TMDS_D1+: DA5.4 (IO3), DA5.7, J3.4 (D1+), U19.28 (TX1+)
/HDMI, GbE, USB/TMDS_D1-: DA5.5 (IO4), DA5.6, J3.6 (D1-), U19.27 (TX1-)
/HDMI, GbE, USB/TMDS_D2+: DA5.1 (IO1), DA5.10, J3.1 (D2+), U19.31 (TX2+)
/HDMI, GbE, USB/TMDS_D2-: DA5.2 (IO2), DA5.9, J3.3 (D2-), U19.30 (TX2-)
/HDMI, GbE, USB/USB1V8: C169.1, C171.1, C173.1, U22.15 (VDD1.8), U22.26 (VDD1.8), U22.29 (VDDA1.8)
/HDMI, GbE, USB/USBA_D+: J4.3 (D+), U22.7 (DP)
/HDMI, GbE, USB/USBA_D-: J4.2 (D-), U22.8 (DM)
/HDMI, GbE, USB/USBA_VBUS: C137.1, J4.1 (VBUS), R73.2, U20.1 (OUT)
/HDMI, GbE, USB/USB_XI: C151.2, R72.1, U22.28 (XI), Y3.2
/HDMI, GbE, USB/USB_XO: C147.2, R72.2, U22.27 (XO), Y3.1
DVI_CLK: U19.57 (IDCLK+); also elsewhere on the board
DVI_D0: U19.63 (DATA0); also elsewhere on the board
DVI_D1: U19.62 (DATA1); also elsewhere on the board
DVI_D2: U19.61 (DATA2); also elsewhere on the board
DVI_D3: U19.60 (DATA3); also elsewhere on the board
DVI_D4: U19.59 (DATA4); also elsewhere on the board
DVI_D5: U19.58 (DATA5); also elsewhere on the board
DVI_D6: U19.55 (DATA6); also elsewhere on the board
DVI_D7: U19.54 (DATA7); also elsewhere on the board
DVI_D8: U19.53 (DATA8); also elsewhere on the board
DVI_D9: U19.52 (DATA9); also elsewhere on the board
DVI_D10: U19.51 (DATA10); also elsewhere on the board
DVI_D11: U19.50 (DATA11); also elsewhere on the board
DVI_D12: U19.47 (DATA12); also elsewhere on the board
DVI_D13: U19.46 (DATA13); also elsewhere on the board
DVI_D14: U19.45 (DATA14); also elsewhere on the board
DVI_D15: U19.44 (DATA15); also elsewhere on the board
DVI_D16: U19.43 (DATA16); also elsewhere on the board
DVI_D17: U19.42 (DATA17); also elsewhere on the board
DVI_D18: U19.41 (DATA18); also elsewhere on the board
DVI_D19: U19.40 (DATA19); also elsewhere on the board
DVI_D20: U19.39 (DATA20); also elsewhere on the board
DVI_D21: U19.38 (DATA21); also elsewhere on the board
DVI_D22: U19.37 (DATA22); also elsewhere on the board
DVI_D23: U19.36 (DATA23); also elsewhere on the board
DVI_DE: U19.2 (DE); also elsewhere on the board
DVI_HSYNC: U19.4 (HSYNC); also elsewhere on the board
DVI_SCL: R68.2, U18.3 (SCL1), U19.15 (BSEL/SCL); also elsewhere on the board
DVI_SDA: R67.2, U18.4 (SDA1), U19.14 (DSEL/SDA); also elsewhere on the board
DVI_VSYNC: U19.5 (VSYNC); also elsewhere on the board
ETH_INT_N: RN5.4 (R4.1), U21.38 (INT_N/PME_N2); also elsewhere on the board
ETH_MDC: U21.36 (MDC); also elsewhere on the board
ETH_MDIO: RN5.3 (R3.1), U21.37 (MDIO); also elsewhere on the board
ETH_~RESET: RN6.2 (R2.1), U21.42 (RESET_N); also elsewhere on the board
GND: C119.1, C120.1, C121.2, C122.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, C129.2, C130.2, C131.2, C132.2, C133.2, C134.2, C135.2, C136.1, C137.2, C138.2, C139.2, C140.1, C141.1, C142.2, C143.2, C144.2, C145.1, C146.2, C147.1, C148.2, C149.2, C150.2, C151.1, C152.2, C153.2, C154.2, C155.2, C156.2, C157.2, C158.2, C159.2, C160.2, C161.2, C162.2, C163.2, C164.2, C165.2, C166.2, C167.2, C168.2, C169.2, C170.2, C171.2, C172.2, C173.2, C255.2, DA5.3 (GND), DA5.8, DA6.3 (GND), DA6.8, J3.2 (D2S), J3.5 (D1S), J3.8 (D0S), J3.11 (CKS), J3.17 (GND), J3.SH, J4.4 (GND), J4.5 (Shield), J13.6 (VSS), J13.9 (SHIELD), P4.13 (LED2-), P4.15 (LED1-), P4.S, R70.2, R71.1, R74.2, RN5.7 (R2.2), RN6.5 (R4.2), RN6.6 (R3.2), U17.2 (GND)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; also elsewhere on the board
unnamed: C121.1, R61.1, U18.7 (VREF2), U18.8 (EN)
unnamed: C132.1, P4.12 (MXCT1)
unnamed: C133.1, P4.6 (MXCT2)
unnamed: C134.1, P4.1 (MXCT3)
unnamed: C135.1, P4.7 (MXCT4)
unnamed: P4.14 (LED2+), R64.2
unnamed: P4.16 (LED1+), R63.2
unnamed: R62.1, U19.19 (TFADJ)
unnamed: R65.1, U19.9 (EDGE/HTPLG)
unnamed: R66.1, U19.13 (ISEL/~RST)
unnamed: R70.1, U20.4 (~EN)
unnamed: R71.2, U21.48 (ISET)
unnamed: R73.1, U22.4 (VBUS)
unnamed: R74.1, U22.32 (RBIAS)
RGMII_REF_CLK: RN6.1 (R1.1), U21.41 (CLK125_NDO/LED_MODE); also elsewhere on the board
RGMII_RXD0: RN4.4 (R4.1), U21.32 (RXD0/MODE0); also elsewhere on the board
RGMII_RXD1: RN4.3 (R3.1), U21.31 (RXD1/MODE1); also elsewhere on the board
RGMII_RXD2: RN4.2 (R2.1), U21.28 (RXD2/MODE2); also elsewhere on the board
RGMII_RXD3: RN4.1 (R1.1), U21.27 (RXD3/MODE3); also elsewhere on the board
RGMII_RX_CLK: RN5.2 (R2.1), U21.35 (RX_CLK/PHYAD2); also elsewhere on the board
RGMII_RX_DV: RN5.1 (R1.1), U21.33 (RX_DV/CLK125_EN); also elsewhere on the board
RGMII_TXD0: U21.19 (TXD0); also elsewhere on the board
RGMII_TXD1: U21.20 (TXD1); also elsewhere on the board
RGMII_TXD2: U21.21 (TXD2); also elsewhere on the board
RGMII_TXD3: U21.22 (TXD3); also elsewhere on the board
RGMII_TX_CLK: U21.24 (GTX_CLK); also elsewhere on the board
RGMII_TX_EN: U21.25 (TX_EN); also elsewhere on the board
ULPI_CLKO: U22.14 (CLKOUT); also elsewhere on the board
ULPI_D0: U22.24 (DATA0); also elsewhere on the board
ULPI_D1: U22.23 (DATA1); also elsewhere on the board
ULPI_D2: U22.22 (DATA2); also elsewhere on the board
ULPI_D3: U22.21 (DATA3); also elsewhere on the board
ULPI_D4: U22.20 (DATA4); also elsewhere on the board
ULPI_D5: U22.19 (DATA5); also elsewhere on the board
ULPI_D6: U22.18 (DATA6); also elsewhere on the board
ULPI_D7: U22.17 (DATA7); also elsewhere on the board
ULPI_DIR: U22.12 (DIR); also elsewhere on the board
ULPI_NXT: U22.11 (NXT); also elsewhere on the board
ULPI_RESET: U22.9 (RESET); also elsewhere on the board
ULPI_STP: U22.13 (STP); also elsewhere on the board
USD_CLK: J13.5 (CLK); also elsewhere on the board
USD_CMD: J13.3 (CMD), RN24.3 (R3.1); also elsewhere on the board
USD_D0: J13.7 (DAT0), RN24.4 (R4.1); also elsewhere on the board
USD_D1: J13.8 (DAT1), R96.2; also elsewhere on the board
USD_D2: J13.1 (DAT2), RN24.1 (R1.1); also elsewhere on the board
USD_D3: J13.2 (DAT3/CD), RN24.2 (R2.1); also elsewhere on the board

Parts:
D14, D15, D16, D17, D18, D19: 150141YB73100; Wurth_BiLED_150141_3528
D20, D21, D22, D23, D24, D25: 150141RV73100; Wurth_BiLED_150141_3528
RN7, RN10, RN11, RN13, RN14, RN15: 2.2k; R_Array_Convex_4x0402
RN8, RN9, RN12: 10k; R_Array_Convex_4x0402
SW1: CHP-081TA; DipSW_CHP-081TA
SW2, SW3, SW4, SW5: SW_Push; SW_SPST_B3S-1000

Connections:
+1V35: SW1.9, SW1.10, SW1.11, SW1.12, SW1.13, SW1.14, SW1.15, SW1.16, SW2.2, SW3.2, SW4.2, SW5.2; also elsewhere on the board
+3V3: RN7.1 (R1.1), RN7.2 (R2.1), RN7.3 (R3.1), RN7.4 (R4.1), RN11.1 (R1.1), RN11.2 (R2.1), RN11.3 (R3.1), RN11.4 (R4.1), RN14.1 (R1.1), RN14.2 (R2.1), RN14.3 (R3.1), RN14.4 (R4.1); also elsewhere on the board
BTN0: RN12.8 (R1.2), SW2.1; also elsewhere on the board
BTN1: RN12.7 (R2.2), SW3.1; also elsewhere on the board
BTN2: RN12.6 (R3.2), SW4.1; also elsewhere on the board
BTN3: RN12.5 (R4.2), SW5.1; also elsewhere on the board
DIP_SW0: RN8.8 (R1.2), SW1.1; also elsewhere on the board
DIP_SW1: RN8.7 (R2.2), SW1.2; also elsewhere on the board
DIP_SW2: RN8.6 (R3.2), SW1.3; also elsewhere on the board
DIP_SW3: RN8.5 (R4.2), SW1.4; also elsewhere on the board
DIP_SW4: RN9.8 (R1.2), SW1.5; also elsewhere on the board
DIP_SW5: RN9.7 (R2.2), SW1.6; also elsewhere on the board
DIP_SW6: RN9.6 (R3.2), SW1.7; also elsewhere on the board
DIP_SW7: RN9.5 (R4.2), SW1.8; also elsewhere on the board
GND: RN8.1 (R1.1), RN8.2 (R2.1), RN8.3 (R3.1), RN8.4 (R4.1), RN9.1 (R1.1), RN9.2 (R2.1), RN9.3 (R3.1), RN9.4 (R4.1), RN10.5 (R4.2), RN10.6 (R3.2), RN10.7 (R2.2), RN10.8 (R1.2), RN12.1 (R1.1), RN12.2 (R2.1), RN12.3 (R3.1), RN12.4 (R4.1), RN13.5 (R4.2), RN13.6 (R3.2), RN13.7 (R2.2), RN13.8 (R1.2), RN15.5 (R4.2), RN15.6 (R3.2), RN15.7 (R2.2), RN15.8 (R1.2); also elsewhere on the board
LED0: D14.2 (A2), D14.3 (K1); also elsewhere on the board
LED1: D15.2 (A2), D15.3 (K1); also elsewhere on the board
LED2: D16.2 (A2), D16.3 (K1); also elsewhere on the board
LED3: D17.2 (A2), D17.3 (K1); also elsewhere on the board
LED4: D18.2 (A2), D18.3 (K1); also elsewhere on the board
LED5: D19.2 (A2), D19.3 (K1); also elsewhere on the board
LED6: D20.2 (A2), D20.3 (K1); also elsewhere on the board
LED7: D21.2 (A2), D21.3 (K1); also elsewhere on the board
LED8: D22.2 (A2), D22.3 (K1); also elsewhere on the board
LED9: D23.2 (A2), D23.3 (K1); also elsewhere on the board
LED10: D24.2 (A2), D24.3 (K1); also elsewhere on the board
LED11: D25.2 (A2), D25.3 (K1); also elsewhere on the board
unnamed: D14.1 (A1), RN7.8 (R1.2)
unnamed: D14.4 (K2), RN10.1 (R1.1)
unnamed: D15.1 (A1), RN7.7 (R2.2)
unnamed: D15.4 (K2), RN10.2 (R2.1)
unnamed: D16.1 (A1), RN7.6 (R3.2)
unnamed: D16.4 (K2), RN10.3 (R3.1)
unnamed: D17.1 (A1), RN7.5 (R4.2)
unnamed: D17.4 (K2), RN10.4 (R4.1)
unnamed: D18.1 (A1), RN11.8 (R1.2)
unnamed: D18.4 (K2), RN13.1 (R1.1)
unnamed: D19.1 (A1), RN11.7 (R2.2)
unnamed: D19.4 (K2), RN13.2 (R2.1)
unnamed: D20.1 (A1), RN11.6 (R3.2)
unnamed: D20.4 (K2), RN13.3 (R3.1)
unnamed: D21.1 (A1), RN11.5 (R4.2)
unnamed: D21.4 (K2), RN13.4 (R4.1)
unnamed: D22.1 (A1), RN14.8 (R1.2)
unnamed: D22.4 (K2), RN15.1 (R1.1)
unnamed: D23.1 (A1), RN14.7 (R2.2)
unnamed: D23.4 (K2), RN15.2 (R2.1)
unnamed: D24.1 (A1), RN14.6 (R3.2)
unnamed: D24.4 (K2), RN15.3 (R3.1)
unnamed: D25.1 (A1), RN14.5 (R4.2)
unnamed: D25.4 (K2), RN15.4 (R4.1)

Notes on the sheet:
BLUE
YELLOW
RED
GREEN
