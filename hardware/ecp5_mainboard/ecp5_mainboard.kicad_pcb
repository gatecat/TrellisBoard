# Repository gatecat/TrellisBoard (continued)

## KiCad design hardware/ecp5_mainboard/ecp5_mainboard.kicad_pcb (continued)

Parts:
C174, C176, C177, C178, C180: 10µ; C_0805_2012Metric
C175, C179, C181, C201, C202, C207, C208: 100n; C_0402_1005Metric
C182: 10µ; C_0603_1608Metric
C183, C184: 4.7µ; C_0603_1608Metric
C185, C186, C187, C188, C189, C190, C191, C192, C193, C194, C195, C196, C197, C198, C199, C200, C203, C204, C205, C206, C209, C210, C211, C212: 470n; C_0402_1005Metric
R75, R76: 51; R_0402_1005Metric
R77, R78, R79: 10k; R_0402_1005Metric
R80, R81: 240; R_0402_1005Metric
RN16, RN17, RN18, RN19, RN20, RN21: 51; R_Array_Convex_4x0402
U23, U24: AS4C256M16D3; BGA-96_9.0x13.0mm_Layout2x3x16_P0.8mm
U25: TPS51200DRC; VSON-10-1EP_3x3mm_P0.5mm_EP1.65x2.4mm

Connections:
+1V35: C178.1, C180.1, C183.1, C184.1, C185.1, C186.1, C187.1, C188.1, C189.1, C190.1, C191.1, C192.1, C193.1, C194.1, C195.1, C196.1, C197.1, C198.1, C199.1, C200.1, C203.1, C204.1, C205.1, C206.1, C209.1, C210.1, C211.1, C212.1, R77.2, U23.A1 (VddQ), U23.A8 (VddQ), U23.B2 (Vdd), U23.C1 (VddQ), U23.C9 (VddQ), U23.D2 (VddQ), U23.D9 (Vdd), U23.E9 (VddQ), U23.F1 (VddQ), U23.G7 (Vdd), U23.H2 (VddQ), U23.H9 (VddQ), U23.K2 (Vdd), U23.K8 (Vdd), U23.N1 (Vdd), U23.N9 (Vdd), U23.R1 (Vdd), U23.R9 (Vdd), U24.A1 (VddQ), U24.A8 (VddQ), U24.B2 (Vdd), U24.C1 (VddQ), U24.C9 (VddQ), U24.D2 (VddQ), U24.D9 (Vdd), U24.E9 (VddQ), U24.F1 (VddQ), U24.G7 (Vdd), U24.H2 (VddQ), U24.H9 (VddQ), U24.K2 (Vdd), U24.K8 (Vdd), U24.N1 (Vdd), U24.N9 (Vdd), U24.R1 (Vdd), U24.R9 (Vdd), U25.2 (VLDOIN); also elsewhere on the board
+3V3: C182.1, R79.2, U25.10 (VIN); also elsewhere on the board
/DDR3/DDR3_VTT: C174.1, C176.1, C177.1, RN16.5 (R4.2), RN16.6 (R3.2), RN16.7 (R2.2), RN16.8 (R1.2), RN17.5 (R4.2), RN17.6 (R3.2), RN17.7 (R2.2), RN17.8 (R1.2), RN18.5 (R4.2), RN18.6 (R3.2), RN18.7 (R2.2), RN18.8 (R1.2), RN19.5 (R4.2), RN19.6 (R3.2), RN19.7 (R2.2), RN19.8 (R1.2), RN20.5 (R4.2), RN20.6 (R3.2), RN20.7 (R2.2), RN20.8 (R1.2), RN21.5 (R4.2), RN21.6 (R3.2), RN21.7 (R2.2), RN21.8 (R1.2), U25.3 (VO), U25.5 (VOSNS)
DDR3_A0: RN19.4 (R4.1), U23.N3 (A0), U24.N3 (A0); also elsewhere on the board
DDR3_A1: RN18.2 (R2.1), U23.P7 (A1), U24.P7 (A1); also elsewhere on the board
DDR3_A2: RN16.4 (R4.1), U23.P3 (A2), U24.P3 (A2); also elsewhere on the board
DDR3_A3: RN20.2 (R2.1), U23.N2 (A3), U24.N2 (A3); also elsewhere on the board
DDR3_A4: RN18.1 (R1.1), U23.P8 (A4), U24.P8 (A4); also elsewhere on the board
DDR3_A5: RN20.1 (R1.1), U23.P2 (A5), U24.P2 (A5); also elsewhere on the board
DDR3_A6: RN17.1 (R1.1), U23.R8 (A6), U24.R8 (A6); also elsewhere on the board
DDR3_A7: RN16.3 (R3.1), U23.R2 (A7), U24.R2 (A7); also elsewhere on the board
DDR3_A8: RN17.2 (R2.1), U23.T8 (A8), U24.T8 (A8); also elsewhere on the board
DDR3_A9: RN16.2 (R2.1), U23.R3 (A9), U24.R3 (A9); also elsewhere on the board
DDR3_A10: RN19.1 (R1.1), U23.L7 (A10/AP), U24.L7 (A10/AP); also elsewhere on the board
DDR3_A11: RN17.4 (R4.1), U23.R7 (A11), U24.R7 (A11); also elsewhere on the board
DDR3_A12: RN18.3 (R3.1), U23.N7 (A12/~BC), U24.N7 (A12/~BC); also elsewhere on the board
DDR3_A13: RN16.1 (R1.1), U23.T3 (A13), U24.T3 (A13); also elsewhere on the board
DDR3_A14: RN17.3 (R3.1), U23.T7 (A14), U24.T7 (A14); also elsewhere on the board
DDR3_BA0: RN20.3 (R3.1), U23.M2 (BA0), U24.M2 (BA0); also elsewhere on the board
DDR3_BA1: RN18.4 (R4.1), U23.N8 (BA1), U24.N8 (BA1); also elsewhere on the board
DDR3_BA2: RN19.3 (R3.1), U23.M3 (BA2), U24.M3 (BA2); also elsewhere on the board
DDR3_CAS: RN21.4 (R4.1), U23.J3 (~RAS), U24.J3 (~RAS); also elsewhere on the board
DDR3_CKE: RN21.3 (R3.1), U23.K9 (CKE), U24.K9 (CKE); also elsewhere on the board
DDR3_CLK+: R75.1, U23.J7 (CK+), U24.J7 (CK+); also elsewhere on the board
DDR3_CLK-: R76.2, U23.K7 (CK-), U24.K7 (CK-); also elsewhere on the board
DDR3_CS: RN20.4 (R4.1), U23.L2 (~CS), U24.L2 (~CS); also elsewhere on the board
DDR3_DM0: U23.E7 (LDM); also elsewhere on the board
DDR3_DM1: U23.D3 (UDM); also elsewhere on the board
DDR3_DM2: U24.E7 (LDM); also elsewhere on the board
DDR3_DM3: U24.D3 (UDM); also elsewhere on the board
DDR3_DQ0: U23.E3 (DQ0); also elsewhere on the board
DDR3_DQ1: U23.F7 (DQ1); also elsewhere on the board
DDR3_DQ2: U23.F2 (DQ2); also elsewhere on the board
DDR3_DQ3: U23.F8 (DQ3); also elsewhere on the board
DDR3_DQ4: U23.H3 (DQ4); also elsewhere on the board
DDR3_DQ5: U23.H8 (DQ5); also elsewhere on the board
DDR3_DQ6: U23.G2 (DQ6); also elsewhere on the board
DDR3_DQ7: U23.H7 (DQ7); also elsewhere on the board
DDR3_DQ8: U23.D7 (DQ8); also elsewhere on the board
DDR3_DQ9: U23.C3 (DQ9); also elsewhere on the board
DDR3_DQ10: U23.C8 (DQ10); also elsewhere on the board
DDR3_DQ11: U23.C2 (DQ11); also elsewhere on the board
DDR3_DQ12: U23.A7 (DQ12); also elsewhere on the board
DDR3_DQ13: U23.A2 (DQ13); also elsewhere on the board
DDR3_DQ14: U23.B8 (DQ14); also elsewhere on the board
DDR3_DQ15: U23.A3 (DQ15); also elsewhere on the board
DDR3_DQ16: U24.E3 (DQ0); also elsewhere on the board
DDR3_DQ17: U24.F7 (DQ1); also elsewhere on the board
DDR3_DQ18: U24.F2 (DQ2); also elsewhere on the board
DDR3_DQ19: U24.F8 (DQ3); also elsewhere on the board
DDR3_DQ20: U24.H3 (DQ4); also elsewhere on the board
DDR3_DQ21: U24.H8 (DQ5); also elsewhere on the board
DDR3_DQ22: U24.G2 (DQ6); also elsewhere on the board
DDR3_DQ23: U24.H7 (DQ7); also elsewhere on the board
DDR3_DQ24: U24.D7 (DQ8); also elsewhere on the board
DDR3_DQ25: U24.C3 (DQ9); also elsewhere on the board
DDR3_DQ26: U24.C8 (DQ10); also elsewhere on the board
DDR3_DQ27: U24.C2 (DQ11); also elsewhere on the board
DDR3_DQ28: U24.A7 (DQ12); also elsewhere on the board
DDR3_DQ29: U24.A2 (DQ13); also elsewhere on the board
DDR3_DQ30: U24.B8 (DQ14); also elsewhere on the board
DDR3_DQ31: U24.A3 (DQ15); also elsewhere on the board
DDR3_DQS0+: U23.F3 (LDQS+); also elsewhere on the board
DDR3_DQS0-: U23.G3 (LDQS-); also elsewhere on the board
DDR3_DQS1+: U23.C7 (UDQS+); also elsewhere on the board
DDR3_DQS1-: U23.B7 (UDQS-); also elsewhere on the board
DDR3_DQS2+: U24.F3 (LDQS+); also elsewhere on the board
DDR3_DQS2-: U24.G3 (LDQS-); also elsewhere on the board
DDR3_DQS3+: U24.C7 (UDQS+); also elsewhere on the board
DDR3_DQS3-: U24.B7 (UDQS-); also elsewhere on the board
DDR3_ODT: RN21.2 (R2.1), U23.K1 (ODT), U24.K1 (ODT); also elsewhere on the board
DDR3_RAS: RN21.1 (R1.1), U23.K3 (~CAS), U24.K3 (~CAS); also elsewhere on the board
DDR3_RESET: U23.T2 (~RESET), U24.T2 (~RESET); also elsewhere on the board
DDR3_Vref: C181.1, C201.1, C202.1, C207.1, C208.1, U23.H1 (VrefDQ), U23.M8 (VrefCA), U24.H1 (VrefDQ), U24.M8 (VrefCA), U25.6 (REFOUT); also elsewhere on the board
DDR3_Vtt_EN: U25.7 (EN); also elsewhere on the board
DDR3_WE: RN19.2 (R2.1), U23.L3 (~WE), U24.L3 (~WE); also elsewhere on the board
GND: C174.2, C175.1, C176.2, C177.2, C178.2, C179.2, C180.2, C181.2, C182.2, C183.2, C184.2, C185.2, C186.2, C187.2, C188.2, C189.2, C190.2, C191.2, C192.2, C193.2, C194.2, C195.2, C196.2, C197.2, C198.2, C199.2, C200.2, C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, R78.1, R80.2, R81.2, U23.A9 (Vss), U23.B1 (VssQ), U23.B3 (Vss), U23.B9 (VssQ), U23.D1 (VssQ), U23.D8 (VssQ), U23.E1 (Vss), U23.E2 (VssQ), U23.E8 (VssQ), U23.F9 (VssQ), U23.G1 (VssQ), U23.G8 (Vss), U23.G9 (VssQ), U23.J2 (Vss), U23.J8 (Vss), U23.M1 (Vss), U23.M9 (Vss), U23.P1 (Vss), U23.P9 (Vss), U23.T1 (Vss), U23.T9 (Vss), U24.A9 (Vss), U24.B1 (VssQ), U24.B3 (Vss), U24.B9 (VssQ), U24.D1 (VssQ), U24.D8 (VssQ), U24.E1 (Vss), U24.E2 (VssQ), U24.E8 (VssQ), U24.F9 (VssQ), U24.G1 (VssQ), U24.G8 (Vss), U24.G9 (VssQ), U24.J2 (Vss), U24.J8 (Vss), U24.M1 (Vss), U24.M9 (Vss)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; also elsewhere on the board
unnamed: C175.2, R75.2, R76.1
unnamed: C179.1, R77.1, R78.2, U25.1 (REFIN)
unnamed: R79.1, U25.9 (PGOOD)
unnamed: R80.1, U23.L8 (ZQ)
unnamed: R81.1, U24.L8 (ZQ)
