# Repository gatecat/TrellisBoard

File README.md:

# Ultimate ECP5 Board

WIP - Rev 1.0 prototypes currently under test...

## Key Features
 - Largest ECP5; LFE5UM5G-85F
 - PCIe 2.0 x2 card edge connector on two SERDES channels
 - Remaining two SERDES channels on M.2 E-key connector
 - 1GByte x32 DDR3L (two x16 chips)
 - Dedicated HDMI output, using TFP410 serialiser
 - 1000BASE-T GbE connector with RGMII PHY
 - USB-A 2.0 host connector with ULPI PHY
 - FT2232H for debug JTAG and UART/FIFO with type-C connector
 - PCIe, external 12V or USB power input
 - 12 bicolour (tristate) user LEDs, 4 user buttons, 8 user DIP switches
 - 128Mbit QSPI flash for boot and data
 - microSD card connector
 - Dual PMOD connector with extra "middle" IO pins
 - As many remaining IO as possible on high speed FFC connectors with a differential optimised pinout (3x 24 IO). Selectable 1.8V/2.5V/3.3V

## Layout
 - PCIe card form factor
 - At least Ethernet, USB-A, USB type-C power/debug and HDMI out
 - Other connectors probably would have to be on other sides. FFC connectors probably on top so they can loop over to another card to form a 2-slot card (e.g. with ADCs/DACs for SDR/DAQ)

## Possible accessories using high-speed FFC connectors
 - MIPI DSI smartphone-style LCDs
 - MIPI CSI-2 cameras
 - High speed ADC/DAC
 - HDMI in/out, direct or using serialiser chip
 - LVDS video in/out for LCDs or block cameras
 - Breakout board to dual or triple PMOD

## KiCad design hardware/ecp5_mainboard/ecp5_mainboard.kicad_pcb

Parts:
C1, C10: 1µ; C_0603_1608Metric
C2: 100µF/25V; CP_Elec_6.3x5.8
C3, C4, C5, C14, C15, C16, C17, C18, C23, C24, C25, C26, C27, C28, C29, C30: 10µ; C_0805_2012Metric
C6: 22µ/25V; C_1206_3216Metric
C7: 100n; C_0402_1005Metric
C8: 100n/25V; C_0805_2012Metric
C9: 1.8n; C_0402_1005Metric
C11: 180p; C_0402_1005Metric
C12: 750p; C_0402_1005Metric
C13, C256: 47µ; C_1210_3225Metric
C19, C20, C21, C22: 120p; C_0402_1005Metric
D2, D4, D5, D6, D7, D8, D9, D10, D11: GREEN; LED_0805_2012Metric
D3: MBR15U60; TO-277B
F1: 3A/DNF; FuseHolder_SMD_Shurter_0031.7701.11
F2: 3A; FuseHolder_SMD_Shurter_0031.7701.11
J1: 12V_EXT; BarrelJack_Horizontal
L1: 800nH/XAL5030; L_Coilcraft_XAL5030
L2: 3.3µH/XAL6030-332; L_CoilCraft_XAL60xx
L3, L4, L5, L6: 470n/IHLP1212; L_Vishay_IHLP-1212
Q1, Q3, Q5, Q6, Q7, Q8: BSH111BKR; SOT-23
Q2, Q4: BC850; SOT-23
R2: 1.5k; R_0402_1005Metric
R3, R9: 4.7k; R_0402_1005Metric
R4: 10; R_0402_1005Metric
R5: 47k; R_0402_1005Metric
R6, R8, R10, R11, R13, R16, R26, R27, R28, R29: 10k; R_0402_1005Metric
R7, R15, R17, R30, R31, R32, R33: 1k; R_0402_1005Metric
R12: 54.9k; R_0402_1005Metric
R14: 470k; R_0402_1005Metric
R18: 124k; R_0402_1005Metric
R19, R21, R23, R25: 100k; R_0402_1005Metric
R20: 453k; R_0402_1005Metric
R22: 316k; R_0402_1005Metric
R24: 200k; R_0402_1005Metric
RN1: 10k; R_Array_Convex_4x0402
TP3: 1.2VA; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP4: 1.2V; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP5: 5V; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP6, TP7: GND; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP8: 1.2VT; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP9: 3.3V; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP10: 2.5V; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP11: 1.35V; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP12: 1.8V; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
U1: MAX811MEUS-T; SOT-143
U2: LM3880; SOT-23-6
U3, U6: TLV75712PDR; TI_WSON8_2x2mm_p0.65mm
U4: TPS565208; SOT-23-6
U5: LM21212-2; HTSSOP-20-1EP_4.4x6.5mm_P0.65mm_EP3.4x6.5mm
U7, U8, U9, U10: TPS62823; TI_VSON-HR_1.5x2mm_p0.5mm

Connections:
+1V2: C12.1, C256.1, L1.2, R10.1, TP4.1; also elsewhere on the board
+1V2A: C5.1, R6.2, TP3.1, U3.1 (OUT); also elsewhere on the board
+1V2T: C14.1, R16.2, TP8.1, U6.1 (OUT); also elsewhere on the board
+1V8: C22.1, C26.1, C30.1, L6.2, R24.1, R29.1, TP12.1; also elsewhere on the board
+1V35: C19.1, C23.1, C27.1, L3.2, R18.1, R28.1, TP11.1; also elsewhere on the board
+2V5: C1.1, C10.1, C21.1, C25.1, C29.1, L5.2, R22.1, R27.1, TP10.1, U3.4 (EN), U3.6 (IN), U6.4 (EN), U6.6 (IN); also elsewhere on the board
+3V3: C20.1, C24.1, C28.1, D5.2 (A), D7.2 (A), L4.2, R8.2, R15.1, R20.1, R26.1, R30.1, R31.1, R32.1, R33.1, TP9.1; also elsewhere on the board
+5V: C3.1, C4.1, C13.1, C15.1, C16.1, C17.1, C18.1, L2.2, R2.1, R4.1, R12.1, RN1.6 (R3.2), RN1.7 (R2.2), RN1.8 (R1.2), TP5.1, U1.4 (VCC), U2.1 (VCC), U5.5 (PVin), U5.6 (PVin), U5.7 (PVin), U7.7 (Vin), U8.7 (Vin), U9.7 (Vin), U10.7 (Vin); also elsewhere on the board
+12V: C2.1, C6.1, D3.3 (K), F1.1, F2.1, R3.1, U4.3 (VIN), U4.5 (EN)
/Power/1V2_EN: RN1.1 (R1.1), U2.6 (FLAG1), U5.3 (EN)
/Power/1V2_PG: Q3.1 (G), R8.1, U5.17 (PGOOD)
/Power/1V8_PG: Q8.1 (G), R29.2, U10.8 (PG)
/Power/1V35_EN: RN1.2 (R2.1), U2.5 (FLAG2), U7.1 (EN), U8.1 (EN), U10.1 (EN)
/Power/1V35_PG: Q7.1 (G), R28.2, U7.8 (PG)
/Power/2V5_EN: RN1.3 (R3.1), U2.4 (FLAG3), U9.1 (EN)
/Power/2V5_PG: Q6.1 (G), R27.2, U9.8 (PG)
/Power/3V3_PG: Q5.1 (G), R26.2, U8.8 (PG)
/Power/PWR_EN: Q1.1 (G), U1.2 (~RESET), U2.3 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C10.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C256.2, D3.1 (A), D3.2 (A), D4.1 (K), J1.2, J1.3, Q1.2 (S), Q2.2 (E), Q3.2 (S), Q4.2 (E), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), R5.1, R11.2, R13.2, R19.2, R21.2, R23.2, R25.2, TP6.1, TP7.1, U1.1 (GND), U2.2 (GND), U3.3 (GND), U3.7 (PAD), U4.1 (GND), U5.8 (PGND), U5.9 (PGND), U5.10 (PGND), U5.20 (AGND), U5.21 (EP), U6.3 (GND), U6.7 (PAD), U7.3 (AGND), U7.5 (PGND), U8.3 (AGND), U8.5 (PGND), U9.3 (AGND), U9.5 (PGND), U10.3 (AGND), U10.5 (PGND); also elsewhere on the board
unnamed: C7.1, R4.2, U5.4 (AVin)
unnamed: C8.1, L2.1, U4.2 (SW)
unnamed: C8.2, U4.6 (Vbst)
unnamed: C9.1, R9.2
unnamed: C11.1, R9.1, R10.2, R11.1, R14.2, U5.19 (FB)
unnamed: C9.2, C11.2, U5.18 (COMP)
unnamed: C12.2, R14.1
unnamed: C19.2, R18.2, R19.1, U7.2 (FB)
unnamed: C20.2, R20.2, R21.1, U8.2 (FB)
unnamed: C21.2, R22.2, R23.1, U9.2 (FB)
unnamed: C22.2, R24.2, R25.1, U10.2 (FB)
unnamed: D2.1 (K), Q1.3 (D)
unnamed: D2.2 (A), R2.2
unnamed: D4.2 (A), R3.2
unnamed: D5.1 (K), R7.2
unnamed: D6.1 (K), Q3.3 (D)
unnamed: D6.2 (A), R15.2
unnamed: D7.1 (K), R17.2
unnamed: D8.1 (K), Q5.3 (D)
unnamed: D8.2 (A), R30.2
unnamed: D9.1 (K), Q6.3 (D)
unnamed: D9.2 (A), R31.2
unnamed: D10.1 (K), Q7.3 (D)
unnamed: D10.2 (A), R32.2
unnamed: D11.1 (K), Q8.3 (D)
unnamed: D11.2 (A), R33.2
unnamed: F2.2, J1.1
unnamed: L1.1, U5.11 (SW), U5.12 (SW), U5.13 (SW), U5.14 (SW), U5.15 (SW), U5.16 (SW)
unnamed: L3.1, U7.6 (SW)
unnamed: L4.1, U8.6 (SW)
unnamed: L5.1, U9.6 (SW)
unnamed: L6.1, U10.6 (SW)
unnamed: Q2.1 (B), R6.1
unnamed: Q2.3 (C), R7.1
unnamed: Q4.1 (B), R16.1
unnamed: Q4.3 (C), R17.1
unnamed: R5.2, U5.1 (FAdj)
unnamed: R12.2, R13.1, U4.4 (Vfb)
PCIe_12V: F1.2; also elsewhere on the board

Notes on the sheet:
in socket
fit socket but no fuse, optional for PCIe power
12V/2.5A input
3.3V/3A
2.5V/3A
1.8V/3A
1.35V/3A
1.2V/1A SERDES analog
1.2V/1A SERDES termination

Parts:
C31, C33, C34, C83, C84: 47µ; C_1210_3225Metric
C32, C35, C36, C37, C80, C81, C85: 4.7µ; C_0603_1608Metric
C38, C39, C40, C41, C44, C45, C48, C51, C52, C53, C54, C55, C56, C57, C58, C61, C64, C67, C70, C71, C72, C73, C74, C75, C76, C77, C78, C79, C82: 470n; C_0402_1005Metric
C42, C43, C46, C47, C62, C63, C65, C66: 10n; C_0201_0603Metric
C49, C50, C59, C60: 1n; C_0201_0603Metric
C68, C69: 100n; C_0402_1005Metric
C86: 47µ; C_1206_3216Metric
L7, L8, L9, L10, L11: 100R@100MHz; L_0603_1608Metric
U15: ECP5UM5G_85_CABGA756; CABGA756_27x27mm_p0.8mm

Connections:
+1V2: C31.1, C32.1, C35.1, C38.1, C41.1, C44.1, C45.1, C48.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, U15.AA12 (VCC), U15.AA13 (VCC), U15.AA14 (VCC), U15.AA15 (VCC), U15.AA16 (VCC), U15.AA17 (VCC), U15.AA18 (VCC), U15.AA19 (VCC), U15.AA20 (VCC), U15.AA21 (VCC), U15.M12 (VCC), U15.M13 (VCC), U15.M14 (VCC), U15.M15 (VCC), U15.M16 (VCC), U15.M17 (VCC), U15.M18 (VCC), U15.M19 (VCC), U15.M20 (VCC), U15.M21 (VCC), U15.N12 (VCC), U15.N21 (VCC), U15.P12 (VCC), U15.P21 (VCC), U15.R12 (VCC), U15.R21 (VCC), U15.T12 (VCC), U15.T21 (VCC), U15.U12 (VCC), U15.U21 (VCC), U15.V12 (VCC), U15.V21 (VCC), U15.W12 (VCC), U15.W21 (VCC), U15.Y12 (VCC), U15.Y21 (VCC); also elsewhere on the board
+1V2A: L9.1, L10.1; also elsewhere on the board
+1V2T: L7.1, L8.1; also elsewhere on the board
+2V5: L11.1; also elsewhere on the board
/FPGA Core Power/VCCA0: C46.1, C49.1, C59.1, C62.1, C65.1, C68.1, C71.1, C74.1, C77.1, C80.1, C83.1, L9.2, U15.AC14 (VCCHRX0_D0CH0), U15.AC18 (VCCHRX0_D1CH0), U15.AG9 (VCCA0), U15.AG12 (VCCA0), U15.AH9 (VCCA0), U15.AH12 (VCCA0), U15.AJ9 (VCCA0), U15.AJ10 (VCCA0), U15.AJ12 (VCCA0), U15.AJ13 (VCCA0)
/FPGA Core Power/VCCA1: C47.1, C50.1, C60.1, C63.1, C66.1, C69.1, C72.1, C75.1, C78.1, C81.1, C84.1, L10.2, U15.AC15 (VCCHRX1_D0CH1), U15.AC19 (VCCHRX1_D1CH1), U15.AF22 (VCCA1), U15.AG19 (VCCA1), U15.AG22 (VCCA1), U15.AH19 (VCCA1), U15.AH22 (VCCA1), U15.AJ18 (VCCA1), U15.AJ19 (VCCA1), U15.AJ21 (VCCA1), U15.AJ22 (VCCA1)
/FPGA Core Power/VCCAUX: C58.1, C61.1, C64.1, C67.1, C70.1, C73.1, C76.1, C79.1, C82.1, C85.1, C86.1, L11.2, U15.AC11 (VCCAUX), U15.AC22 (VCCAUX), U15.AJ15 (VCCAUXA0), U15.AJ16 (VCCAUXA0), U15.AJ24 (VCCAUXA1), U15.AJ25 (VCCAUXA1), U15.K13 (VCCAUX), U15.K20 (VCCAUX), U15.N10 (VCCAUX), U15.N23 (VCCAUX), U15.Y10 (VCCAUX), U15.Y23 (VCCAUX)
/FPGA Core Power/VCCHTX0: C34.1, C37.1, C40.1, C43.1, L8.2, U15.AC13 (VCCHTX0_D0CH0), U15.AC17 (VCCHTX0_D1CH0)
/FPGA Core Power/VCCHTX1: C33.1, C36.1, C39.1, C42.1, L7.2, U15.AC16 (VCCHTX1_D0CH1), U15.AC20 (VCCHTX1_D1CH1)
GND: C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, U15.AA11 (GND), U15.AA22 (GND), U15.AB11 (GND), U15.AB12 (GND), U15.AB13 (GND), U15.AB14 (GND), U15.AB15 (GND), U15.AB16 (GND), U15.AB17 (GND), U15.AB18 (GND), U15.AB19 (GND), U15.AB20 (GND), U15.AB21 (GND), U15.AB22 (GND), U15.AC12 (GND), U15.AC21 (GND), U15.AD2 (GND), U15.AD5 (GND), U15.AD28 (GND), U15.AD31 (GND), U15.AF11 (GND), U15.AF12 (GND), U15.AF14 (GND), U15.AF15 (GND)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; also elsewhere on the board

Parts:
C87, C91, C92, C94, C95, C97, C98: 470n; C_0402_1005Metric
C88: 100n; C_0402_1005Metric
C89, C90, C93, C96: 4.7µ; C_0603_1608Metric
D12: GREEN; LED_0805_2012Metric
J2: USB_B_Micro; USB_Micro-B_Molex-105017-0001
L12, L13: Ferrite_Bead; L_0603_1608Metric
R34, R35: 0R; R_0402_1005Metric
R36, R37: 22; R_0402_1005Metric
R38: 2.2k; R_0402_1005Metric
R39: 12k; R_0402_1005Metric
R40, R41: 10k; R_0402_1005Metric
R42, R43, R44, R45: 0R; R_0805_2012Metric
R46: 1.5k; R_0402_1005Metric
RN2: 10k; R_Array_Convex_4x0402
RN3: R_Pack04; R_Array_Convex_4x0402
U12: 93AA46B_OT; SOT-23-6
U13: FT2232H; LQFP-64_10x10mm_P0.5mm
X1: XO32; Oscillator_SMD_EuroQuartz_XO32-4Pin_3.2x2.5mm

Connections:
+1V8: C93.1, C94.1, C95.1, U13.12 (VCORE), U13.37 (VCORE), U13.64 (VCORE); also elsewhere on the board
+3V3: C87.1, C88.1, C96.1, C97.1, C98.1, L12.2, L13.2, R40.2, R46.1, RN2.1 (R1.1), RN2.2 (R2.1), RN2.3 (R3.1), RN2.4 (R4.1), RN3.5 (R4.2), RN3.6 (R3.2), RN3.7 (R2.2), RN3.8 (R1.2), U12.6 (Vcc), U13.20 (VCCIO), U13.31 (VCCIO), U13.42 (VCCIO), U13.56 (VCCIO), X1.4 (V+); also elsewhere on the board
/Debug Interface/FTDI_12MHz: R36.1, U13.2 (OSCI)
/Debug Interface/FTDI_D+: R35.1, U13.8 (DP)
/Debug Interface/FTDI_D-: R34.1, U13.7 (DM)
/Debug Interface/JTAG_ACT: D12.1 (K), U13.21 (ADBUS4)
/Debug Interface/PORT_D+: J2.3 (D+), R35.2
/Debug Interface/PORT_D-: J2.2 (D-), R34.2
/Debug Interface/Vphy: C90.1, C92.1, L12.1, U13.4 (VPHY)
/Debug Interface/Vpll: C89.1, C91.1, L13.1, U13.9 (VPLL)
FPGA_12MHz: R37.1; also elsewhere on the board
FTDI_D0_TX: U13.38 (BDBUS0); also elsewhere on the board
FTDI_D1_RX: RN3.1 (R1.1), U13.39 (BDBUS1); also elsewhere on the board
FTDI_D2: U13.40 (BDBUS2); also elsewhere on the board
FTDI_D3: U13.41 (BDBUS3); also elsewhere on the board
FTDI_D4: U13.43 (BDBUS4); also elsewhere on the board
FTDI_D5: U13.44 (BDBUS5); also elsewhere on the board
FTDI_D6: U13.45 (BDBUS6); also elsewhere on the board
FTDI_D7: U13.46 (BDBUS7); also elsewhere on the board
FTDI_~RD: RN3.2 (R2.1), U13.53 (BCBUS2); also elsewhere on the board
FTDI_~RXF: U13.48 (BCBUS0); also elsewhere on the board
FTDI_~SIWU: RN3.4 (R4.1), U13.55 (BCBUS4); also elsewhere on the board
FTDI_~TXE: U13.52 (BCBUS1); also elsewhere on the board
FTDI_~WR: RN3.3 (R3.1), U13.54 (BCBUS3); also elsewhere on the board
GND: C87.2, C88.2, C89.2, C90.2, C91.2, C92.2, C93.2, C94.2, C95.2, C96.2, C97.2, C98.2, J2.5 (GND), J2.6 (Shield), R39.2, R41.2, U12.2 (GND), U13.1 (GND), U13.5 (GND), U13.10 (AGND), U13.11 (GND), U13.13 (TEST), U13.15 (GND), U13.25 (GND), U13.35 (GND), U13.47 (GND), U13.51 (GND), X1.2 (GND); also elsewhere on the board
JTAG_TCK: R41.1, R42.1; also elsewhere on the board
JTAG_TDI: R43.1; also elsewhere on the board
JTAG_TDO: R44.1; also elsewhere on the board
JTAG_TMS: R45.1; also elsewhere on the board
unnamed: D12.2 (A), R46.2
unnamed: R36.2, R37.2, X1.3 (OUT)
unnamed: R38.1, U12.3 (DI), U13.61 (EEDATA)
unnamed: R38.2, RN2.8 (R1.2), U12.1 (DO)
unnamed: R39.1, U13.6 (REF)
unnamed: R40.1, U13.14 (~RESET)
unnamed: R42.2, U13.16 (ADBUS0)
unnamed: R43.2, U13.17 (ADBUS1)
unnamed: R44.2, U13.18 (ADBUS2)
unnamed: R45.2, U13.19 (ADBUS3)
unnamed: RN2.6 (R3.2), U12.4 (CLK), U13.62 (EECLK)
unnamed: RN2.7 (R2.2), U12.5 (CS), U13.63 (EECS)
