# Repository gatecat/TrellisBoard (continued)

## KiCad design hardware/ecp5_mainboard/ecp5_mainboard.kicad_pcb (continued)

Parts:
C213, C214, C253: 100n; C_0402_1005Metric
C215, C216, C217, C218, C224, C225, C226, C227, C229, C230, C231, C232, C234, C235, C236, C237, C238, C239, C241, C242, C244, C245, C246, C247, C248, C249, C251, C252, C254: 470n; C_0402_1005Metric
C219, C220, C221, C222, C223, C228, C233, C240, C243, C250: 4.7µ; C_0603_1608Metric
D26: GREEN; LED_0805_2012Metric
D27: RED; LED_0805_2012Metric
J5: EXT0; TE_FPC_40pin_p0.5mm_4-1734839-0
J6: EXT1; TE_FPC_40pin_p0.5mm_4-1734839-0
J7: EXT2; TE_FPC_40pin_p0.5mm_4-1734839-0
J9: PMOD_01; PinHeader_2x15_P2.54mm_Horizontal
J10: UART; PinHeader_1x04_P2.54mm_Vertical
J11: FLASH; PinHeader_2x04_P2.54mm_Vertical
J12: JTAG; PinHeader_1x06_P2.54mm_Vertical
JP2: CFG1; PinHeader_1x02_P2.54mm_Vertical
Q9: BSH111BKR; SOT-23
R82, R85: 0R; R_0805_2012Metric
R83, R84, R86, R87: DNP; R_0805_2012Metric
R88: 4.7k; R_0402_1005Metric
R89, R92, R93: 1k; R_0402_1005Metric
R90, R94, R95: 10k; R_0402_1005Metric
R91, R97: 22; R_0402_1005Metric
RN22, RN23: 10k; R_Array_Convex_4x0402
SW6: SW_Push; SW_SPST_B3S-1000
U15: ECP5UM5G_85_CABGA756; CABGA756_27x27mm_p0.8mm
U26: XL_XO_LVDS; OSC_IDT_XU_5x3.2mm
U27: W25Q; SO-8_5.3x6.2mm_P1.27mm

Connections:
+1V8: R84.2, R87.2; also elsewhere on the board
+1V35: C215.1, C216.1, C217.1, C218.1, C219.1, C224.1, C225.1, C226.1, C227.1, C228.1, U15.AA23 (VCCIO3), U15.M23 (VCCIO2), U15.P23 (VCCIO2), U15.R23 (VCCIO2), U15.T23 (VCCIO2), U15.U23 (VCCIO3), U15.V23 (VCCIO3), U15.W23 (VCCIO3); also elsewhere on the board
+2V5: R83.2, R86.2; also elsewhere on the board
+3V3: C234.1, C235.1, C236.1, C238.1, C240.1, C244.1, C245.1, C246.1, C247.1, C248.1, C249.1, C250.1, C251.1, C252.1, C254.1, J9.11, J9.12, J9.29, J9.30, J10.1, J11.1, J12.1, JP2.1, R82.2, R85.2, R88.1, R89.1, R90.1, R92.1, R93.1, R94.1, R95.1, RN22.5 (R4.2), RN22.6 (R3.2), RN22.7 (R2.2), RN22.8 (R1.2), U15.AB10 (VCCIO8), U15.AB23 (VCCIO4), U15.AC10 (VCCIO8), U15.AC23 (VCCIO4), U15.K12 (VCCIO0), U15.K14 (VCCIO0), U15.K15 (VCCIO0), U15.K16 (VCCIO0), U15.K17 (VCCIO1), U15.K18 (VCCIO1), U15.K19 (VCCIO1), U15.K21 (VCCIO1), U26.6 (Vdd), U27.8 (VCC); also elsewhere on the board
/FPGA IO/CFG0: RN23.7 (R2.2), U15.AL4 (CFG_1)
/FPGA IO/CFG1: JP2.2, RN23.6 (R3.2), U15.AK4 (CFG_2)
/FPGA IO/CFG2: RN23.5 (R4.2), U15.AM4 (CFG_0)
/FPGA IO/CLK100+: U15.B29 (PT121A), U26.4 (OUT+)
/FPGA IO/CLK100-: U15.B30 (PT121B), U26.5 (OUT-)
/FPGA IO/DONE: R90.2, R91.2, U15.AJ4 (DONE)
/FPGA IO/EXIO_0: J9.13, U15.D24 (PT103A)
/FPGA IO/EXIO_1: J9.15, U15.A24 (PT101A)
/FPGA IO/EXIO_2: J9.17, U15.F23 (PT98B)
/FPGA IO/EXIO_3: J9.14, U15.F22 (PT92B)
/FPGA IO/EXIO_4: J9.16, U15.E22 (PT92A)
/FPGA IO/EXIO_5: J9.18, U15.B22 (PT87B)
/FPGA IO/EXT0_0+: J5.3, U15.T1 (PL68A)
/FPGA IO/EXT0_0-: J5.4, U15.U1 (PL68B)
/FPGA IO/EXT0_1+: J5.6, U15.AE5 (PL80C)
/FPGA IO/EXT0_1-: J5.7, U15.AE4 (PL80D)
/FPGA IO/EXT0_2+: J5.9, U15.AB5 (PL77A)
/FPGA IO/EXT0_2-: J5.10, U15.AB6 (PL77B)
/FPGA IO/EXT0_3+: J5.12, U15.Y5 (PL71C)
/FPGA IO/EXT0_3-: J5.13, U15.W5 (PL71D)
/FPGA IO/EXT0_4+: J5.15, U15.W2 (PL86A)
/FPGA IO/EXT0_4-: J5.16, U15.Y1 (PL86B)
/FPGA IO/EXT0_5+: J5.18, U15.AB7 (PL74C)
/FPGA IO/EXT0_5-: J5.19, U15.AC6 (PL74D)
/FPGA IO/EXT0_6+: J5.21, U15.AB3 (PL83A)
/FPGA IO/EXT0_6-: J5.22, U15.AB4 (PL83B)
/FPGA IO/EXT0_7+: J5.24, U15.AD3 (PL86C)
/FPGA IO/EXT0_7-: J5.25, U15.AE3 (PL86D)
/FPGA IO/EXT0_8+: J5.27, U15.AB1 (PL92A)
/FPGA IO/EXT0_8-: J5.28, U15.AC1 (PL92B)
/FPGA IO/EXT0_9+: J5.30, U15.AD1 (PL92C)
/FPGA IO/EXT0_9-: J5.31, U15.AE1 (PL92D)
/FPGA IO/EXT0_10+: J5.33, U15.AD6 (PL80A)
/FPGA IO/EXT0_10-: J5.34, U15.AE6 (PL80B)
/FPGA IO/EXT0_11+: J5.36, U15.AC7 (PL77C)
/FPGA IO/EXT0_11-: J5.37, U15.AD7 (PL77D)
/FPGA IO/EXT1_0+: J6.3, U15.P5 (PL47A)
/FPGA IO/EXT1_0-: J6.4, U15.P4 (PL47B)
/FPGA IO/EXT1_1+: J6.6, U15.R7 (PL47C)
/FPGA IO/EXT1_1-: J6.7, U15.T7 (PL47D)
/FPGA IO/EXT1_2+: J6.9, U15.R6 (PL50A)
/FPGA IO/EXT1_2-: J6.10, U15.T6 (PL50B)
/FPGA IO/EXT1_3+: J6.12, U15.U6 (PL50C)
/FPGA IO/EXT1_3-: J6.13, U15.U7 (PL50D)
/FPGA IO/EXT1_4+: J6.15, U15.R4 (PL53A)
/FPGA IO/EXT1_4-: J6.16, U15.T5 (PL53B)
/FPGA IO/EXT1_5+: J6.18, U15.T4 (PL53C)
/FPGA IO/EXT1_5-: J6.19, U15.U5 (PL53D)
/FPGA IO/EXT1_6+: J6.21, U15.U4 (PL56A)
/FPGA IO/EXT1_6-: J6.22, U15.V4 (PL56B)
/FPGA IO/EXT1_7+: J6.24, U15.V6 (PL56C)
/FPGA IO/EXT1_7-: J6.25, U15.V7 (PL56D)
/FPGA IO/EXT1_8+: J6.27, U15.P2 (PL59A)
/FPGA IO/EXT1_8-: J6.28, U15.P3 (PL59B)
/FPGA IO/EXT1_9+: J6.30, U15.R3 (PL59C)
/FPGA IO/EXT1_9-: J6.31, U15.T3 (PL59D)
/FPGA IO/EXT1_10+: J6.33, U15.N1 (PL62A)
/FPGA IO/EXT1_10-: J6.34, U15.P1 (PL62B)
/FPGA IO/EXT1_11+: J6.36, U15.U2 (PL62C)
/FPGA IO/EXT1_11-: J6.37, U15.U3 (PL62D)
/FPGA IO/EXT2_0+: J7.3, U15.K6 (PL38A)
/FPGA IO/EXT2_0-: J7.4, U15.K7 (PL38B)
/FPGA IO/EXT2_1+: J7.6, U15.J7 (PL35C)
/FPGA IO/EXT2_1-: J7.7, U15.J6 (PL35D)
/FPGA IO/EXT2_2+: J7.9, U15.H6 (PL35A)
/FPGA IO/EXT2_2-: J7.10, U15.H5 (PL35B)
/FPGA IO/EXT2_3+: J7.12, U15.F4 (PL14C)
/FPGA IO/EXT2_3-: J7.13, U15.F5 (PL14D)
/FPGA IO/EXT2_4+: J7.15, U15.F3 (PL20A)
/FPGA IO/EXT2_4-: J7.16, U15.E3 (PL20B)
/FPGA IO/EXT2_5+: J7.18, U15.C4 (PL11C)
/FPGA IO/EXT2_5-: J7.19, U15.C3 (PL11D)
/FPGA IO/EXT2_6+: J7.21, U15.C5 (PL11A)
/FPGA IO/EXT2_6-: J7.22, U15.D5 (PL11B)
/FPGA IO/EXT2_7+: J7.24, U15.D3 (PL17C)
/FPGA IO/EXT2_7-: J7.25, U15.D2 (PL17D)
/FPGA IO/EXT2_8+: J7.27, U15.H2 (PL26A)
/FPGA IO/EXT2_8-: J7.28, U15.H3 (PL26B)
/FPGA IO/EXT2_9+: J7.30, U15.J3 (PL26C)
/FPGA IO/EXT2_9-: J7.31, U15.K3 (PL26D)
/FPGA IO/EXT2_10+: J7.33, U15.B1 (PL17A)
/FPGA IO/EXT2_10-: J7.34, U15.C2 (PL17B)
/FPGA IO/EXT2_11+: J7.36, U15.F1 (PL23C)
/FPGA IO/EXT2_11-: J7.37, U15.H1 (PL23D)
/FPGA IO/FLASH_CLK: J11.5, R89.2, U15.AM3 (CCLK), U27.6 (CLK)
/FPGA IO/FLASH_D0: J11.2, RN22.1 (R1.1), U15.AK2 (PB11B), U27.5 (DI/IO0)
/FPGA IO/FLASH_D1: J11.4, RN22.2 (R2.1), U15.AJ2 (PB11A), U27.2 (DO/IO1)
/FPGA IO/FLASH_D2: J11.6, RN22.3 (R3.1), U15.AM2 (PB9B), U27.3 (~WP~/IO2)
/FPGA IO/FLASH_D3: J11.8, RN22.4 (R4.1), U15.AL1 (PB9A), U27.7 (~HLD~/~RST~/IO3)
/FPGA IO/FLASH_~CS: J11.3, R88.2, U15.AJ3 (PB15A), U27.1 (~CS)
/FPGA IO/PMOD0_0: J9.1, U15.A26 (PT112A)
/FPGA IO/PMOD0_1: J9.3, U15.E25 (PT110A)
/FPGA IO/PMOD0_2: J9.5, U15.D25 (PT107B)
/FPGA IO/PMOD0_3: J9.7, U15.B25 (PT105B)
/FPGA IO/PMOD0_7: J9.2, U15.C25 (PT107A)
/FPGA IO/PMOD0_8: J9.4, U15.A25 (PT105A)
/FPGA IO/PMOD0_9: J9.6, U15.F24 (PT103B)
/FPGA IO/PMOD0_10: J9.8, U15.C24 (PT101B)
/FPGA IO/PMOD1_0: J9.19, U15.D23 (PT96B)
/FPGA IO/PMOD1_1: J9.21, U15.E23 (PT98A)
/FPGA IO/PMOD1_2: J9.23, U15.C23 (PT96A)
/FPGA IO/PMOD1_3: J9.25, U15.B23 (PT94B)
/FPGA IO/PMOD1_7: J9.20, U15.F20 (PT85B)
/FPGA IO/PMOD1_8: J9.22, U15.C20 (PT83B)
/FPGA IO/PMOD1_9: J9.24, U15.E14 (PT45B)
/FPGA IO/PMOD1_10: J9.26, U15.D14 (PT47A)
/FPGA IO/VCCIO6: C220.1, C222.1, C229.1, C230.1, C231.1, C232.1, C233.1, J5.1, J5.2, J5.39, J5.40, J6.1, J6.2, J6.39, J6.40, R82.1, R83.1, R84.1, U15.AA10 (VCCIO6), U15.U10 (VCCIO6), U15.V10 (VCCIO6), U15.W10 (VCCIO6)
/FPGA IO/VCCIO7: C221.1, C223.1, C237.1, C239.1, C241.1, C242.1, C243.1, J7.1, J7.2, J7.39, J7.40, R85.1, R86.1, R87.1, U15.M10 (VCCIO7), U15.P10 (VCCIO7), U15.R10 (VCCIO7), U15.T10 (VCCIO7)
/FPGA IO/~INIT: D27.1 (K), R94.2, U15.AG4 (INITN)
/FPGA IO/~PROGRAM: C253.1, R95.2, SW6.2, U15.AH4 (PROGRAMN)
BTN0: U15.Y32 (PR86B); also elsewhere on the board
BTN1: U15.AD30 (PR86C); also elsewhere on the board
BTN2: U15.W31 (PR86A); also elsewhere on the board
BTN3: U15.AD29 (PR83D); also elsewhere on the board
CLK_SCL: U15.A22 (PT87A); also elsewhere on the board
CLK_SDA: U15.C22 (PT89A); also elsewhere on the board
CLK_SD_OE: U15.A4 (PT9A); also elsewhere on the board
DDR3_A0: U15.E30 (PR20B); also elsewhere on the board
DDR3_A1: U15.F28 (PR14D); also elsewhere on the board
DDR3_A2: U15.C32 (PR20C); also elsewhere on the board
DDR3_A3: U15.E29 (PR14B); also elsewhere on the board
DDR3_A4: U15.F32 (PR23C); also elsewhere on the board
DDR3_A5: U15.D30 (PR17C); also elsewhere on the board
DDR3_A6: U15.E32 (PR23B); also elsewhere on the board
DDR3_A7: U15.D29 (PR14A); also elsewhere on the board
DDR3_A8: U15.D32 (PR20D); also elsewhere on the board
DDR3_A9: U15.C31 (PR17B); also elsewhere on the board
DDR3_A10: U15.H32 (PR23D); also elsewhere on the board
DDR3_A11: U15.F31 (PR23A); also elsewhere on the board
DDR3_A12: U15.F29 (PR14C); also elsewhere on the board
DDR3_A13: U15.B32 (PR17A); also elsewhere on the board
DDR3_A14: U15.D31 (PR17D); also elsewhere on the board
DDR3_BA0: U15.H31 (PR26A); also elsewhere on the board
DDR3_BA1: U15.H30 (PR26B); also elsewhere on the board
DDR3_BA2: U15.J30 (PR26C); also elsewhere on the board
DDR3_CAS: U15.K31 (PR29A); also elsewhere on the board
DDR3_CKE: U15.K32 (PR29C); also elsewhere on the board
DDR3_CLK+: U15.L31 (PR32A); also elsewhere on the board
DDR3_CLK-: U15.L30 (PR32B); also elsewhere on the board
DDR3_CS: U15.K29 (PR32D); also elsewhere on the board
DDR3_DM0: U15.R26 (PR47C); also elsewhere on the board
DDR3_DM1: U15.L27 (PR41D); also elsewhere on the board
DDR3_DM2: U15.Y27 (PR71B); also elsewhere on the board
DDR3_DM3: U15.U31 (PR62C); also elsewhere on the board
DDR3_DQ0: U15.V26 (PR56D); also elsewhere on the board
DDR3_DQ1: U15.R27 (PR50A); also elsewhere on the board
DDR3_DQ2: U15.V27 (PR56C); also elsewhere on the board
DDR3_DQ3: U15.T26 (PR47D); also elsewhere on the board
DDR3_DQ4: U15.U28 (PR53D); also elsewhere on the board
DDR3_DQ5: U15.T27 (PR50B); also elsewhere on the board
DDR3_DQ6: U15.T29 (PR53C); also elsewhere on the board
DDR3_DQ7: U15.U26 (PR50D); also elsewhere on the board
DDR3_DQ8: U15.P27 (PR44C); also elsewhere on the board
DDR3_DQ9: U15.K28 (PR38C); also elsewhere on the board
DDR3_DQ10: U15.P26 (PR44D); also elsewhere on the board
DDR3_DQ11: U15.L26 (PR41C); also elsewhere on the board
DDR3_DQ12: U15.K27 (PR38A); also elsewhere on the board
DDR3_DQ13: U15.N26 (PR44B); also elsewhere on the board
DDR3_DQ14: U15.L29 (PR38D); also elsewhere on the board
DDR3_DQ15: U15.K26 (PR38B); also elsewhere on the board
DDR3_DQ16: U15.AC27 (PR74D); also elsewhere on the board
DDR3_DQ17: U15.W28 (PR71D); also elsewhere on the board
DDR3_DQ18: U15.AC26 (PR77C); also elsewhere on the board
DDR3_DQ19: U15.Y26 (PR71A); also elsewhere on the board
DDR3_DQ20: U15.AB26 (PR74C); also elsewhere on the board
DDR3_DQ21: U15.W29 (PR74B); also elsewhere on the board
DDR3_DQ22: U15.AD26 (PR77D); also elsewhere on the board
DDR3_DQ23: U15.Y28 (PR71C); also elsewhere on the board
DDR3_DQ24: U15.T32 (PR68A); also elsewhere on the board
DDR3_DQ25: U15.U32 (PR68B); also elsewhere on the board
DDR3_DQ26: U15.P31 (PR59A); also elsewhere on the board
DDR3_DQ27: U15.V32 (PR68C); also elsewhere on the board
DDR3_DQ28: U15.P32 (PR62B); also elsewhere on the board
DDR3_DQ29: U15.W32 (PR68D); also elsewhere on the board
DDR3_DQ30: U15.N32 (PR62A); also elsewhere on the board
DDR3_DQ31: U15.U30 (PR62D); also elsewhere on the board
DDR3_DQS0+: U15.R29 (PR53A); also elsewhere on the board
DDR3_DQS0-: U15.T28 (PR53B); also elsewhere on the board
DDR3_DQS1+: U15.N30 (PR41A); also elsewhere on the board
DDR3_DQS1-: U15.N29 (PR41B); also elsewhere on the board
DDR3_DQS2+: U15.AB28 (PR77A); also elsewhere on the board
DDR3_DQS2-: U15.AB27 (PR77B); also elsewhere on the board
DDR3_DQS3+: U15.R32 (PR65A); also elsewhere on the board
DDR3_DQS3-: U15.T31 (PR65B); also elsewhere on the board
DDR3_ODT: U15.J29 (PR32C); also elsewhere on the board
DDR3_RAS: U15.K30 (PR26D); also elsewhere on the board
DDR3_RESET: U15.L32 (PR29D); also elsewhere on the board
DDR3_Vref: C213.1, C214.1, U15.J26 (PR35C), U15.V29 (PR56B); also elsewhere on the board
DDR3_Vtt_EN: U15.F25 (PT110B); also elsewhere on the board
DDR3_WE: U15.J32 (PR29B); also elsewhere on the board
DIP_SW0: U15.AE32 (PR92D); also elsewhere on the board
DIP_SW1: U15.AD32 (PR92C); also elsewhere on the board
DIP_SW2: U15.AC32 (PR92B); also elsewhere on the board
DIP_SW3: U15.AB32 (PR92A); also elsewhere on the board
DIP_SW4: U15.AE31 (PR89D); also elsewhere on the board
DIP_SW5: U15.AB31 (PR89B); also elsewhere on the board
DIP_SW6: U15.AC31 (PR89C); also elsewhere on the board
DIP_SW7: U15.AC30 (PR89A); also elsewhere on the board
DVI_CLK: U15.F8 (PT15A); also elsewhere on the board
DVI_D0: U15.F14 (PT45A); also elsewhere on the board
DVI_D1: U15.A13 (PT42B); also elsewhere on the board
DVI_D2: U15.D13 (PT40B); also elsewhere on the board
DVI_D3: U15.C13 (PT42A); also elsewhere on the board
DVI_D4: U15.F13 (PT40A); also elsewhere on the board
DVI_D5: U15.A11 (PT38B); also elsewhere on the board
DVI_D6: U15.C11 (PT36B); also elsewhere on the board
DVI_D7: U15.B11 (PT38A); also elsewhere on the board
DVI_D8: U15.D11 (PT36A); also elsewhere on the board
DVI_D9: U15.E11 (PT33B); also elsewhere on the board
DVI_D10: U15.A10 (PT31B); also elsewhere on the board
DVI_D11: U15.F11 (PT33A); also elsewhere on the board
DVI_D12: U15.B10 (PT31A); also elsewhere on the board
DVI_D13: U15.C10 (PT29B); also elsewhere on the board
DVI_D14: U15.E10 (PT27B); also elsewhere on the board
DVI_D15: U15.D10 (PT29A); also elsewhere on the board
DVI_D16: U15.F10 (PT27A); also elsewhere on the board
DVI_D17: U15.A9 (PT24B); also elsewhere on the board
DVI_D18: U15.D9 (PT22B); also elsewhere on the board
DVI_D19: U15.C9 (PT24A); also elsewhere on the board
DVI_D20: U15.F9 (PT22A); also elsewhere on the board
DVI_D21: U15.A8 (PT20B); also elsewhere on the board
DVI_D22: U15.C8 (PT18B); also elsewhere on the board
DVI_D23: U15.B8 (PT20A); also elsewhere on the board
DVI_DE: U15.D8 (PT18A); also elsewhere on the board
DVI_HSYNC: U15.A7 (PT13B); also elsewhere on the board
DVI_SCL: U15.C7 (PT11B); also elsewhere on the board
DVI_SDA: U15.B7 (PT13A); also elsewhere on the board
DVI_VSYNC: U15.E8 (PT15B); also elsewhere on the board
ETH_INT_N: U15.B14 (PT49A); also elsewhere on the board
ETH_MDC: U15.D17 (PT65B); also elsewhere on the board
ETH_MDIO: U15.B17 (PT63B); also elsewhere on the board
ETH_~RESET: U15.C14 (PT47B); also elsewhere on the board
FABRIC_REFCLK: U15.E17 (PT69A); also elsewhere on the board
FPGA_12MHz: U15.B3 (PT4A); also elsewhere on the board
FTDI_D0_TX: J10.3, U15.AM28 (PB96A); also elsewhere on the board
FTDI_D1_RX: J10.2, U15.AL28 (PB98A); also elsewhere on the board
FTDI_D2: U15.AM29 (PB96B); also elsewhere on the board
FTDI_D3: U15.AK28 (PB98B); also elsewhere on the board
FTDI_D4: U15.AK32 (PB101A); also elsewhere on the board
FTDI_D5: U15.AM30 (PB103A); also elsewhere on the board
FTDI_D6: U15.AJ32 (PB101B); also elsewhere on the board
FTDI_D7: U15.AL30 (PB103B); also elsewhere on the board
FTDI_~RD: U15.AL32 (PB107B); also elsewhere on the board
FTDI_~RXF: U15.AM31 (PB107A); also elsewhere on the board
FTDI_~SIWU: U15.AJ28 (PB112A); also elsewhere on the board
FTDI_~TXE: U15.AJ31 (PB105B); also elsewhere on the board
FTDI_~WR: U15.AG28 (PB110A); also elsewhere on the board
GND: C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, C220.2, C221.2, C222.2, C223.2, C224.2, C225.2, C226.2, C227.2, C228.2, C229.2, C230.2, C231.2, C232.2, C233.2, C234.2, C235.2, C236.2, C237.2, C238.2, C239.2, C240.2, C241.2, C242.2, C243.2, C244.2, C245.2, C246.2, C247.2, C248.2, C249.2, C250.2, C251.2, C252.2, C253.2, C254.2, J5.5, J5.8, J5.11, J5.14, J5.17, J5.20, J5.23, J5.26, J5.29, J5.32, J5.35, J6.5, J6.8, J6.11, J6.14, J6.17, J6.20, J6.23, J6.26, J6.29, J6.32, J6.35, J7.5, J7.8, J7.11, J7.14, J7.17, J7.20, J7.23, J7.26, J7.29, J7.32, J7.35, J9.9, J9.10, J9.27, J9.28, J10.4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; also elsewhere on the board
JTAG_TCK: J12.3, U15.AK5 (TCK); also elsewhere on the board
JTAG_TDI: J12.4, U15.AJ5 (TDI); also elsewhere on the board
JTAG_TDO: J12.2, U15.AG5 (TDO); also elsewhere on the board
JTAG_TMS: J12.5, U15.AM5 (TMS); also elsewhere on the board
LED0: U15.AG29 (PB110B); also elsewhere on the board
LED1: U15.AH28 (PB112B); also elsewhere on the board
LED2: U15.AH30 (PB114A); also elsewhere on the board
LED3: U15.AK29 (PB116A); also elsewhere on the board
LED4: U15.AG30 (PB114B); also elsewhere on the board
LED5: U15.AK30 (PB116B); also elsewhere on the board
LED6: U15.AH32 (PB119A); also elsewhere on the board
LED7: U15.A30 (PT119A); also elsewhere on the board
LED8: U15.A29 (PT116B); also elsewhere on the board
LED9: U15.D26 (PT114B); also elsewhere on the board
LED10: U15.A28 (PT116A); also elsewhere on the board
LED11: U15.C26 (PT114A); also elsewhere on the board
unnamed: D26.1 (K), Q9.3 (D)
unnamed: D26.2 (A), R92.2
unnamed: D27.2 (A), R93.2
unnamed: Q9.1 (G), R91.1
unnamed: R97.1, U15.AK3 (PB15B)
PCIe_~WAKE: U15.A23 (PT94A); also elsewhere on the board
RGMII_REF_CLK: U15.A17 (PT63A); also elsewhere on the board
RGMII_RXD0: U15.C15 (PT54A); also elsewhere on the board
RGMII_RXD1: U15.D15 (PT51B); also elsewhere on the board
RGMII_RXD2: U15.A14 (PT49B); also elsewhere on the board
RGMII_RXD3: U15.F15 (PT51A); also elsewhere on the board
RGMII_RX_CLK: U15.C17 (PT65A); also elsewhere on the board
RGMII_RX_DV: U15.F16 (PT56A); also elsewhere on the board
RGMII_TXD0: U15.A16 (PT60B); also elsewhere on the board
RGMII_TXD1: U15.C16 (PT58B); also elsewhere on the board
RGMII_TXD2: U15.B16 (PT60A); also elsewhere on the board
RGMII_TXD3: U15.D16 (PT58A); also elsewhere on the board
RGMII_TX_CLK: U15.E16 (PT56B); also elsewhere on the board
RGMII_TX_EN: U15.A15 (PT54B); also elsewhere on the board
ULPI_CLKO: U15.A18 (PT71A); also elsewhere on the board
ULPI_D0: U15.F18 (PT74B); also elsewhere on the board
ULPI_D1: U15.B19 (PT76B); also elsewhere on the board
ULPI_D2: U15.C19 (PT78A); also elsewhere on the board
ULPI_D3: U15.E19 (PT80A); also elsewhere on the board
ULPI_D4: U15.D19 (PT78B); also elsewhere on the board
ULPI_D5: U15.F19 (PT80B); also elsewhere on the board
ULPI_D6: U15.A20 (PT83A); also elsewhere on the board
ULPI_D7: U15.D20 (PT85A); also elsewhere on the board
ULPI_DIR: U15.D18 (PT74A); also elsewhere on the board
ULPI_NXT: U15.A19 (PT76A); also elsewhere on the board
ULPI_RESET: U15.F17 (PT69B); also elsewhere on the board
ULPI_STP: U15.C18 (PT71B); also elsewhere on the board
USD_CLK: R97.2; also elsewhere on the board
USD_CMD: U15.AH3 (PB13B); also elsewhere on the board
USD_D0: U15.AG1 (PB4A); also elsewhere on the board
USD_D1: U15.AJ1 (PB6A); also elsewhere on the board
USD_D2: U15.AH1 (PB4B); also elsewhere on the board
USD_D3: U15.AK1 (PB6B); also elsewhere on the board
~PERST: U15.D22 (PT89B); also elsewhere on the board

Board: 8 copper layers, 200.0 x 111.2 mm, 507 parts (213 on the bottom side), 513 nets.

## Commit log

2018-07-28 Add README with specs
2018-07-28 hardware/lib: Add ECP5 library generated by KiPart
2018-07-28 ecp5_mainboard: Adding empty KiCad project
2018-07-28 hardware/lib: PCIe x4 edge symbol
2018-07-28 hardware/lib: Add mDP source and sink connector symbols
2018-07-28 hardware/lib: Add ARJ-202B dual magjack symbol
2018-07-29 hardware/lib: Add power library components
2018-07-29 ecp5_mainboard/power: Add power input circuitry
2018-07-29 ecp5_mainboard/power: Add 1.8V, 2.5V and 3.3V regulators
2018-07-29 ecp5_mainboard/power: Add 1.35V DDR3 and 1.2V FPGA core regulators
2018-07-29 ecp5_mainboard/power: Add 1.2V analog and termination supplies
2018-07-29 ecp5_mainboard/power: Add startup/sequencing control
2018-07-30 ecp5_mainboard/fpga_pwr: Add FPGA power connections
2018-07-30 ecp5_mainboard: Run ERC and fix issues
2018-07-30 ecp5_mainboard/debug: FT2232H JTAG interface and USB-C debug conn
2018-07-31 ecp5_mainboard/debug: Wiring for FTDI 'B' interface
2018-07-31 ecp5_mainboard: Select 1A/3A current limit for debug USB-C power based on CC voltage
2018-08-03 ecp5_mainboard: Adding some 'glue' parts, preparing for USB-C and DP schematics
2018-08-19 ecp5_mainboard: Starting USB-C and DP schematics
2018-08-21 ecp5_mainboard: Working on USBC/DP section
2018-11-19 hardware/mainboard: Major spec change; remove USBC/DP; add PCIe and refclk
2018-11-19 hardware/mainboard: Add SATA and SATA REFCLK
2018-11-19 hardware/mainboard: Adding GbE magjack and phy
2018-11-19 hardware: Add PKL as git submodule
2018-11-19 hardware/mainboard: Finish GbE, add ULPI USB and TFP410 DVI/HDMI-out
2018-11-19 hardware/mainboard: Add switches and LEDs
2018-11-19 hardware/mainboard: Switch debug connector to USB micro-B
2018-11-19 hardware/mainboard: Add DDR3 x32 memory
2018-11-19 hardware/mainboard: Connect DDR3 IO to FPGA IO
2018-11-19 hardware/mainboard: Connecting more FPGA IO
2018-11-19 hardware/mainboard: Pin plan external IO FFCs
2018-11-19 hardware/mainboard: Add config, JTAG and boot flash
2018-11-19 Update README with spec changes
2018-11-20 hardware/mainboard: Connect FTDI and add quasi-dual-PMOD
2018-11-20 hardware/mainboard: Re-annotate and fix ERC
2018-11-20 hardware/mainboard: add microSD
2018-11-20 hardware/mainboard: Assign some footprints
2018-11-21 hardware: Add CABGA756 footprint
2018-11-21 hardware: Add PCIe x4 edge connector footprint
2018-11-21 hardware: Adding USB-A and MagJack footprints
2018-11-21 hardware/mainboard: Assign more footprints
2018-11-21 hardware: Add SATA connector footprint
2018-11-21 hardware: Add HDMI connector footprint
2018-11-21 hardware: Creating and assigning some misc footprints
2018-11-21 hardware/mainboard: More footprint assignment, other small tweaks
2018-11-21 hardware/mainboard: All footprints assigned
2018-11-21 hardware.mainboard: Fixes from PCB import
2018-11-21 hardware/mainboard: Preliminary placement of some major components
2018-11-21 hardware/mainboard: Power related placement
2018-11-22 hardware/mainboard: Power circuitry placed
2018-11-22 hardware/mainboard: Change LEDs to larger Wurth 3528 LEDs
2018-11-22 hardware/mainboard: Configure some 3D shapes
2018-11-23 hardware/mainboard: Place FPGA decoupling
2018-11-23 hardware/mainboard: Place DDR3 decoupling and termination
2018-11-23 hardware/mainboard: All parts placed
2018-11-24 hardware/mainboard: Working on 3D
2018-11-24 hardware/mainboard: Complete 3D models, other footprint tweaks
2018-11-24 hardware/mainboard: Reduce refdes size to 0.8mm
2018-11-24 hardware/mainboard: Tidy up silkscreen
2018-11-24 hardware/mainboard: Small design tweaks
2018-11-24 hardware/mainboard: Set up layers and design rules
2018-11-24 hardware/mainboard: Creating power/ground planes
2018-11-24 hardware/mainboard: FPGA power/ground routing
2018-11-24 hardware/mainboard: Tidying up
2018-11-24 hardware/mainboard: Swapping DDR3 groups
2018-11-25 hardware/mainboard: DDR3 Address routing
2018-11-25 hardware/mainboard: More DDR3 address routing
2018-11-25 hardware/mainboard: Finish DDR3 CA routing inc termination
2018-11-25 hardware/mainboard: DDR3 CA FPGA->chip0 length matching
2018-11-26 hardware/mainboard: DDR3 CA traces length matched with squiggly bois
2018-11-26 hardware/mainboard: Misc routing
2018-11-28 hardware/mainboard: PCIe routing
2018-11-28 hardware/mainboard: Route DDR3 bytes 0 and 1
2018-11-28 hardware/mainboard: Route DDR3 bytes 2 and 3
2018-11-28 hardware/mainboard: All DDR3 traces length matched
2018-11-28 hardware/mainboard: DDR3 power/Vref/Vtt routing
2018-11-28 hardware/mainboard: Route first two IO connectors
2019-02-14 hardware/mainboard: Route EXT2, remove EXT3
2019-02-14 hardware/mainboard: Route out DVI, RGMII, ULPI & PMOD signals from BGA
2019-02-14 hardware/mainboard: Route DVI signals
2019-02-15 hardware/mainboard: Route RGMII signals
2019-02-15 hardware/mainboard: Route ULPI signals
2019-02-15 hardware/mainboard: Route PMOD signals
2019-02-15 hardware/mainboard: Route switch & LED signals
2019-02-15 hardware/mainboard: Miscellaneous routing
2019-02-15 hardware/mainboard: Route FTDI, JTAG, uSD
2019-02-15 hardware/mainboard: Silkscreen improvements
2019-02-16 hardware/mainboard: Switching from SATA to m.2 connector for second DCU
2019-02-16 hardware/mainboard: Add and place M.2 connector footprint
2019-02-17 hardware/mainboard: Repositioning to fit in M.2
2019-02-17 Update README and add license
2019-02-20 hardware/mainboard: Tweak layout around M.2 and add standoffs for 30&42mm cards
2019-02-20 hardware/mainboard: Misc routing, mostly after M.2 changes
2019-02-20 hardware/mainboard: Route M.2 diff pairs
2019-02-22 hardware/mainboard: Power routing
2019-02-22 hardware/mainboard: Clock & M.2 routing
2019-02-23 hardware/mainboard: All routed
2019-02-26 hardware/mainboard: Expansion connector signal tuning
2019-02-26 hardware/mainboard: Add via stitching
2019-02-27 hardware/mainboard: Improve planes
2019-03-22 hardware/mainboard: Misc tidying
2019-03-22 hardware/mainboard: ERC fixes
2019-03-22 hardware/mainboard: DRC fixes
2019-03-24 hardware/mainboard: Outline & text fixes
2019-03-26 hardware/mainboard: Tweaks
2019-04-03 hardware/mainboard: Silkscreen fixes
2019-04-03 hardware/mainboard: BoM fixes, add USB power option
2019-04-03 hardware/mainboard: Switch debug/power connector from micro-B to C
2019-04-07 mainboard: Tidying up
2019-04-07 hardware/mainboard: Unswap GbE pairs
2019-04-07 hardware/mainboard: RefDes silkscreen improvements
2019-04-09 hardware/mainboard: Silk fixes
2019-04-09 hardware/mainboard: Add more mounting holes
2019-05-11 hardware/mainboard: Final production tweaks
2019-05-11 hardware/mainboard: Add schematics PDF
2019-05-12 hardware/mainboard: Add Rev 1.0 production assets
2019-05-12 hardware/mainboard: Add render
2019-05-12 gateware: Add basic LiteX platform file
2019-05-12 gateware/pinout: Add SD, flash, HDMI, ULPI and connectors
2019-05-12 gateware: Restructure, add minimal blinky
2019-06-03 gateware: Blinky working
2019-06-03 gateware: Fix swapped RAS/CAS, seperate out Vtt enable
2019-07-04 gateware/simple: Demo tweaks
